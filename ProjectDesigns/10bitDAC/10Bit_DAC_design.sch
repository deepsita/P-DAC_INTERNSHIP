v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {y7} 5495 1298 0 0 0.2 0.2 {}
N 2530 410 2910 410 { lab=#net1}
N 2530 430 2910 430 { lab=#net2}
N 2530 580 2900 580 { lab=#net3}
N 2530 600 2900 600 { lab=#net4}
N 2540 740 2900 740 { lab=#net5}
N 2540 760 2900 760 { lab=#net6}
N 2540 880 2910 880 { lab=#net7}
N 2540 900 2910 900 { lab=#net8}
N 2540 1020 2910 1020 { lab=#net9}
N 2540 1040 2910 1040 { lab=#net10}
N 2550 1150 2910 1150 { lab=#net11}
N 2550 1170 2910 1170 { lab=#net12}
N 2560 1280 2910 1280 { lab=#net13}
N 2560 1300 2910 1300 { lab=#net14}
N 2560 1410 2910 1410 { lab=#net15}
N 2560 1430 2910 1430 { lab=#net16}
N 2560 1550 2910 1550 { lab=#net17}
N 2560 1570 2910 1570 { lab=#net18}
N 2560 1690 2900 1690 { lab=#net19}
N 2560 1710 2900 1710 { lab=#net20}
N 2570 1820 2910 1820 { lab=#net21}
N 2570 1840 2910 1840 { lab=#net22}
N 2570 1980 2910 1980 { lab=#net23}
N 2570 2000 2910 2000 { lab=#net24}
N 2570 2130 2910 2130 { lab=#net25}
N 2570 2150 2910 2150 { lab=#net26}
N 2560 2280 2910 2280 { lab=#net27}
N 2560 2300 2910 2300 { lab=#net28}
N 2570 2450 2910 2450 { lab=#net29}
N 2570 2470 2910 2470 { lab=#net30}
N 2560 2620 2910 2620 { lab=#net31}
N 2560 2640 2910 2640 { lab=#net32}
N 2560 2760 2910 2760 { lab=#net33}
N 2560 2780 2910 2780 { lab=#net34}
N 2570 2900 2920 2900 { lab=#net35}
N 2570 2920 2920 2920 { lab=#net36}
N 2560 3040 2910 3040 { lab=#net37}
N 2560 3060 2910 3060 { lab=#net38}
N 2570 3180 2910 3180 { lab=#net39}
N 2570 3200 2910 3200 { lab=#net40}
N 2570 3320 2910 3320 { lab=#net41}
N 2570 3340 2910 3340 { lab=#net42}
N 2560 3460 2910 3460 { lab=#net43}
N 2560 3480 2910 3480 { lab=#net44}
N 2560 3600 2910 3600 { lab=#net45}
N 2560 3620 2910 3620 { lab=#net46}
N 2560 3750 2910 3750 { lab=#net47}
N 2560 3770 2910 3770 { lab=#net48}
N 2570 3910 2920 3910 { lab=#net49}
N 2570 3930 2920 3930 { lab=#net50}
N 2570 4060 2930 4060 { lab=#net51}
N 2570 4080 2930 4080 { lab=#net52}
N 2560 4200 2930 4200 { lab=#net53}
N 2560 4220 2930 4220 { lab=#net54}
N 2570 4340 2930 4340 { lab=#net55}
N 2570 4360 2930 4360 { lab=#net56}
N 2560 4480 2930 4480 { lab=#net57}
N 2560 4500 2930 4500 { lab=#net58}
N 2570 4610 2930 4610 { lab=#net59}
N 2570 4630 2930 4630 { lab=#net60}
N 2570 4730 2930 4730 { lab=#net61}
N 2570 4750 2930 4750 { lab=#net62}
N 2560 4860 2930 4860 { lab=#net63}
N 2560 4880 2930 4880 { lab=#net64}
N 3360 3900 3360 3990 { lab=#net65}
N 3360 570 3360 670 { lab=#net66}
N 3200 570 3360 570 { lab=#net66}
N 3200 730 3360 730 { lab=#net67}
N 3360 270 3360 510 { lab=pVref}
N 3210 400 3360 400 { lab=pVref}
N 3360 730 3360 810 { lab=#net67}
N 3210 870 3360 870 { lab=#net68}
N 3360 870 3360 950 { lab=#net68}
N 3210 1010 3360 1010 { lab=#net69}
N 3360 1010 3360 1080 { lab=#net69}
N 3210 1140 3360 1140 { lab=#net70}
N 3360 1140 3360 1210 { lab=#net70}
N 3360 1270 3360 1340 { lab=#net71}
N 3210 1270 3360 1270 { lab=#net71}
N 3360 1400 3360 1480 { lab=#net72}
N 3210 1400 3360 1400 { lab=#net72}
N 3360 1540 3360 1620 { lab=#net73}
N 3210 1540 3360 1540 { lab=#net73}
N 3360 1680 3360 1750 { lab=#net74}
N 3200 1680 3360 1680 { lab=#net74}
N 3210 1810 3360 1810 { lab=#net75}
N 3360 1810 3360 1910 { lab=#net75}
N 3210 1970 3360 1970 { lab=#net76}
N 3360 1970 3360 2060 { lab=#net76}
N 3360 2120 3360 2200 { lab=#net77}
N 3210 2120 3360 2120 { lab=#net77}
N 3210 2270 3360 2270 { lab=#net78}
N 3360 2260 3360 2270 { lab=#net78}
N 3360 2260 3360 2380 { lab=#net78}
N 3360 2440 3360 2540 { lab=#net79}
N 3210 2440 3360 2440 { lab=#net79}
N 3360 2600 3360 2690 { lab=#net80}
N 3210 2610 3360 2610 { lab=#net80}
N 3360 2750 3360 2830 { lab=#net81}
N 3210 2750 3360 2750 { lab=#net81}
N 3360 2890 3360 2970 { lab=#net82}
N 3220 2890 3360 2890 { lab=#net82}
N 3360 3030 3360 3110 { lab=#net83}
N 3210 3030 3360 3030 { lab=#net83}
N 3360 3170 3360 3250 { lab=#net84}
N 3210 3170 3360 3170 { lab=#net84}
N 3360 3310 3360 3390 { lab=#net85}
N 3210 3310 3360 3310 { lab=#net85}
N 3360 3450 3360 3530 { lab=#net86}
N 3210 3450 3360 3450 { lab=#net86}
N 3360 3590 3360 3680 { lab=#net87}
N 3210 3590 3360 3590 { lab=#net87}
N 3360 3740 3360 3840 { lab=#net88}
N 3210 3740 3360 3740 { lab=#net88}
N 3220 3900 3360 3900 { lab=#net65}
N 3230 4050 3360 4050 { lab=#net89}
N 3360 4050 3360 4120 { lab=#net89}
N 3230 4190 3360 4190 { lab=#net90}
N 3360 4180 3360 4270 { lab=#net90}
N 3230 4330 3360 4330 { lab=#net91}
N 3360 4330 3360 4400 { lab=#net91}
N 3230 4470 3360 4470 { lab=#net92}
N 3360 4460 3360 4540 { lab=#net92}
N 3360 4600 3360 4660 { lab=#net93}
N 3230 4600 3360 4600 { lab=#net93}
N 3360 4720 3360 4790 { lab=#net94}
N 3230 4720 3360 4720 { lab=#net94}
N 3230 4850 3360 4850 { lab=#net95}
N 3230 4870 3450 4870 { lab=MSB1_out}
N 3450 4870 3450 4970 { lab=MSB1_out}
N 3210 420 3430 420 { lab=MSB1_out}
N 3430 420 3440 420 { lab=MSB1_out}
N 3200 590 3440 590 { lab=MSB1_out}
N 3230 4740 3450 4740 { lab=MSB1_out}
N 3450 4740 3450 4870 { lab=MSB1_out}
N 3230 4620 3450 4620 { lab=MSB1_out}
N 3450 4620 3450 4740 { lab=MSB1_out}
N 3230 4490 3450 4490 { lab=MSB1_out}
N 3450 4490 3450 4620 { lab=MSB1_out}
N 3230 4350 3440 4350 { lab=MSB1_out}
N 3440 4350 3450 4350 { lab=MSB1_out}
N 3450 4350 3450 4490 { lab=MSB1_out}
N 3230 4210 3450 4210 { lab=MSB1_out}
N 3450 4210 3450 4350 { lab=MSB1_out}
N 3230 4070 3450 4070 { lab=MSB1_out}
N 3450 4070 3450 4210 { lab=MSB1_out}
N 3220 3920 3450 3920 { lab=MSB1_out}
N 3450 3920 3450 4070 { lab=MSB1_out}
N 3210 3760 3450 3760 { lab=MSB1_out}
N 3450 3760 3450 3920 { lab=MSB1_out}
N 3210 3610 3450 3610 { lab=MSB1_out}
N 3450 3610 3450 3760 { lab=MSB1_out}
N 3210 3470 3450 3470 { lab=MSB1_out}
N 3450 3470 3450 3610 { lab=MSB1_out}
N 3210 3330 3450 3330 { lab=MSB1_out}
N 3450 3330 3450 3470 { lab=MSB1_out}
N 3210 3190 3450 3190 { lab=MSB1_out}
N 3450 3190 3450 3330 { lab=MSB1_out}
N 3210 3050 3450 3050 { lab=MSB1_out}
N 3450 3050 3450 3190 { lab=MSB1_out}
N 3220 2910 3450 2910 { lab=MSB1_out}
N 3450 2910 3450 3050 { lab=MSB1_out}
N 3210 2770 3450 2770 { lab=MSB1_out}
N 3450 2770 3450 2910 { lab=MSB1_out}
N 3210 2630 3450 2630 { lab=MSB1_out}
N 3450 2630 3450 2770 { lab=MSB1_out}
N 3210 2460 3450 2460 { lab=MSB1_out}
N 3450 2460 3450 2630 { lab=MSB1_out}
N 3210 2290 3450 2290 { lab=MSB1_out}
N 3450 2290 3450 2460 { lab=MSB1_out}
N 3210 2140 3450 2140 { lab=MSB1_out}
N 3450 2140 3450 2290 { lab=MSB1_out}
N 3210 1990 3450 1990 { lab=MSB1_out}
N 3450 1990 3450 2140 { lab=MSB1_out}
N 3210 1830 3450 1830 { lab=MSB1_out}
N 3450 1830 3450 1990 { lab=MSB1_out}
N 3200 1700 3450 1700 { lab=MSB1_out}
N 3450 1700 3450 1830 { lab=MSB1_out}
N 3210 1560 3430 1560 { lab=MSB1_out}
N 3430 1560 3450 1560 { lab=MSB1_out}
N 3450 1560 3450 1700 { lab=MSB1_out}
N 3210 1420 3450 1420 { lab=MSB1_out}
N 3450 1420 3450 1560 { lab=MSB1_out}
N 3210 1290 3450 1290 { lab=MSB1_out}
N 3450 1290 3450 1420 { lab=MSB1_out}
N 3210 1160 3450 1160 { lab=MSB1_out}
N 3450 1160 3450 1290 { lab=MSB1_out}
N 3210 1030 3450 1030 { lab=MSB1_out}
N 3450 1030 3450 1160 { lab=MSB1_out}
N 3210 890 3450 890 { lab=MSB1_out}
N 3450 890 3450 1030 { lab=MSB1_out}
N 3200 750 3450 750 { lab=MSB1_out}
N 3450 750 3450 890 { lab=MSB1_out}
N 3440 590 3450 590 { lab=MSB1_out}
N 3450 590 3450 750 { lab=MSB1_out}
N 3440 420 3450 420 { lab=MSB1_out}
N 3450 420 3450 590 { lab=MSB1_out}
N 3930 420 4160 420 { lab=MSB2_out}
N 4160 420 4160 600 { lab=MSB2_out}
N 4160 600 4160 750 { lab=MSB2_out}
N 3930 750 4160 750 { lab=MSB2_out}
N 3920 590 4160 590 { lab=MSB2_out}
N 3930 890 4160 890 { lab=MSB2_out}
N 4160 750 4160 890 { lab=MSB2_out}
N 3930 1030 4160 1030 { lab=MSB2_out}
N 4160 890 4160 1030 { lab=MSB2_out}
N 3930 1160 4160 1160 { lab=MSB2_out}
N 4160 1030 4160 1160 { lab=MSB2_out}
N 3930 1290 4160 1290 { lab=MSB2_out}
N 4160 1160 4160 1290 { lab=MSB2_out}
N 3940 1420 4160 1420 { lab=MSB2_out}
N 4160 1290 4160 1420 { lab=MSB2_out}
N 3940 1560 4160 1560 { lab=MSB2_out}
N 4160 1420 4160 1560 { lab=MSB2_out}
N 3950 1700 4160 1700 { lab=MSB2_out}
N 4160 1560 4160 1700 { lab=MSB2_out}
N 3940 1830 4160 1830 { lab=MSB2_out}
N 4160 1700 4160 1830 { lab=MSB2_out}
N 3950 1990 4160 1990 { lab=MSB2_out}
N 4160 1830 4160 1990 { lab=MSB2_out}
N 3950 2140 4160 2140 { lab=MSB2_out}
N 4160 1990 4160 2140 { lab=MSB2_out}
N 3950 2280 4160 2280 { lab=MSB2_out}
N 4160 2140 4160 2280 { lab=MSB2_out}
N 3960 2460 4160 2460 { lab=MSB2_out}
N 4160 2280 4160 2460 { lab=MSB2_out}
N 3960 2630 4160 2630 { lab=MSB2_out}
N 4160 2460 4160 2630 { lab=MSB2_out}
N 3960 2770 4160 2770 { lab=MSB2_out}
N 4160 2630 4160 2770 { lab=MSB2_out}
N 3960 2910 4160 2910 { lab=MSB2_out}
N 4160 2770 4160 2910 { lab=MSB2_out}
N 3990 3050 4160 3050 { lab=MSB2_out}
N 4160 2910 4160 3050 { lab=MSB2_out}
N 3970 3190 4160 3190 { lab=MSB2_out}
N 4160 3050 4160 3190 { lab=MSB2_out}
N 3970 3330 4160 3330 { lab=MSB2_out}
N 4160 3190 4160 3330 { lab=MSB2_out}
N 3970 3470 4160 3470 { lab=MSB2_out}
N 4160 3330 4160 3470 { lab=MSB2_out}
N 3980 3610 4160 3610 { lab=MSB2_out}
N 4160 3470 4160 3610 { lab=MSB2_out}
N 3980 3760 4160 3760 { lab=MSB2_out}
N 4160 3610 4160 3760 { lab=MSB2_out}
N 3980 3920 4160 3920 { lab=MSB2_out}
N 4160 3760 4160 3920 { lab=MSB2_out}
N 3980 4070 4160 4070 { lab=MSB2_out}
N 4160 3920 4160 4070 { lab=MSB2_out}
N 3980 4210 4160 4210 { lab=MSB2_out}
N 4160 4070 4160 4210 { lab=MSB2_out}
N 3980 4330 4160 4330 { lab=MSB2_out}
N 4160 4210 4160 4330 { lab=MSB2_out}
N 3980 4490 4160 4490 { lab=MSB2_out}
N 4160 4330 4160 4490 { lab=MSB2_out}
N 3980 4620 4160 4620 { lab=MSB2_out}
N 4160 4490 4160 4620 { lab=MSB2_out}
N 3980 4740 4160 4740 { lab=MSB2_out}
N 4160 4620 4160 4740 { lab=MSB2_out}
N 3980 4870 4160 4870 { lab=MSB2_out}
N 4160 4740 4160 4870 { lab=MSB2_out}
N 4160 4870 4160 4950 { lab=MSB2_out}
N 3930 400 4050 400 { lab=#net96}
N 4050 400 4050 450 { lab=#net96}
N 4050 510 4050 620 { lab=#net97}
N 3920 570 4050 570 { lab=#net97}
N 4050 680 4050 770 { lab=#net98}
N 3930 730 4050 730 { lab=#net98}
N 4050 830 4050 910 { lab=#net99}
N 3930 870 4050 870 { lab=#net99}
N 4050 970 4050 1050 { lab=#net100}
N 3930 1010 4050 1010 { lab=#net100}
N 4050 1110 4050 1190 { lab=#net101}
N 3930 1140 4050 1140 { lab=#net101}
N 4050 1250 4050 1320 { lab=#net102}
N 3930 1270 4050 1270 { lab=#net102}
N 4050 1380 4050 1450 { lab=#net103}
N 3940 1400 4050 1400 { lab=#net103}
N 4050 1510 4050 1590 { lab=#net104}
N 3940 1540 4050 1540 { lab=#net104}
N 4050 1650 4050 1730 { lab=#net105}
N 3950 1680 4050 1680 { lab=#net105}
N 4050 1790 4050 1860 { lab=#net106}
N 3940 1810 4050 1810 { lab=#net106}
N 4050 1920 4050 2020 { lab=#net107}
N 3950 1970 4050 1970 { lab=#net107}
N 4050 2080 4050 2170 { lab=#net108}
N 3950 2120 4050 2120 { lab=#net108}
N 4050 2230 4050 2310 { lab=#net109}
N 3950 2260 4050 2260 { lab=#net109}
N 4050 2370 4050 2500 { lab=#net110}
N 3960 2440 4050 2440 { lab=#net110}
N 4050 2560 4050 2660 { lab=#net111}
N 3960 2610 4050 2610 { lab=#net111}
N 4050 2720 4050 2800 { lab=#net112}
N 3960 2750 4050 2750 { lab=#net112}
N 4050 2860 4050 2930 { lab=#net113}
N 3960 2890 4050 2890 { lab=#net113}
N 4050 2990 4050 3080 { lab=#net114}
N 3990 3030 4050 3030 { lab=#net114}
N 4050 3140 4050 3220 { lab=#net115}
N 3970 3170 4050 3170 { lab=#net115}
N 4050 3280 4050 3360 { lab=#net116}
N 3970 3310 4050 3310 { lab=#net116}
N 4050 3420 4050 3500 { lab=#net117}
N 3970 3450 4050 3450 { lab=#net117}
N 4050 3560 4050 3640 { lab=#net118}
N 3980 3590 4050 3590 { lab=#net118}
N 4050 3700 4050 3790 { lab=#net119}
N 3980 3740 4050 3740 { lab=#net119}
N 4050 3850 4050 3950 { lab=#net120}
N 3980 3900 4050 3900 { lab=#net120}
N 4050 4010 4050 4100 { lab=#net121}
N 3980 4050 4050 4050 { lab=#net121}
N 4050 4160 4050 4230 { lab=#net122}
N 3980 4190 4050 4190 { lab=#net122}
N 4050 4290 4050 4370 { lab=#net123}
N 3980 4310 4050 4310 { lab=#net123}
N 4050 4430 4050 4510 { lab=#net124}
N 3980 4470 4050 4470 { lab=#net124}
N 4050 4570 4050 4640 { lab=#net125}
N 3980 4600 4050 4600 { lab=#net125}
N 4050 4700 4050 4760 { lab=#net126}
N 3980 4720 4050 4720 { lab=#net126}
N 4050 4820 4050 4960 {lab=nVref}
N 3980 4850 4050 4850 { lab=nVref}
N 2130 390 2230 390 { lab=b9}
N 2130 410 2230 410 { lab=b8}
N 2130 430 2230 430 { lab=b7}
N 2130 450 2230 450 { lab=b6}
N 2130 470 2230 470 { lab=b5}
N 2120 560 2230 560 { lab=b9}
N 2120 580 2230 580 { lab=b8}
N 2120 600 2230 600 { lab=b7}
N 2120 620 2230 620 { lab=b6}
N 2120 640 2230 640 { lab=nb5}
N 2120 720 2240 720 {lab=b9}
N 2120 740 2240 740 { lab=b8}
N 2120 760 2240 760 { lab=b7}
N 2120 780 2240 780 { lab=nb6}
N 2120 800 2240 800 { lab=b5}
N 2120 860 2240 860 { lab=b9}
N 2120 880 2240 880 { lab=b8}
N 2120 900 2240 900 { lab=b7}
N 2120 920 2240 920 { lab=nb6}
N 2120 940 2240 940 { lab=nb5}
N 2130 1000 2240 1000 { lab=b9}
N 2130 1020 2240 1020 { lab=b8}
N 2130 1040 2240 1040 { lab=nb7}
N 2130 1060 2240 1060 { lab=b6}
N 2130 1080 2240 1080 { lab=b5}
N 2130 1130 2250 1130 { lab=b9}
N 2130 1150 2250 1150 { lab=b8}
N 2130 1170 2250 1170 { lab=nb7}
N 2130 1190 2250 1190 { lab=b6}
N 2130 1210 2250 1210 { lab=nb5}
N 2140 1260 2260 1260 { lab=b9}
N 2140 1280 2260 1280 { lab=b8}
N 2140 1300 2260 1300 { lab=nb7}
N 2140 1320 2260 1320 { lab=nb6}
N 2140 1340 2260 1340 { lab=b5}
N 2140 1390 2260 1390 { lab=b9}
N 2140 1410 2260 1410 { lab=b8}
N 2140 1430 2260 1430 { lab=nb7}
N 2140 1450 2260 1450 { lab=nb6}
N 2140 1470 2260 1470 { lab=nb5}
N 2140 1530 2260 1530 { lab=b9}
N 2140 1550 2260 1550 { lab=nb8}
N 2140 1570 2260 1570 { lab=b7}
N 2140 1590 2260 1590 { lab=b6}
N 2140 1610 2260 1610 { lab=b5}
N 2150 1670 2260 1670 { lab=b9}
N 2150 1690 2260 1690 { lab=nb8}
N 2150 1710 2260 1710 { lab=b7}
N 2150 1730 2260 1730 { lab=b6}
N 2150 1750 2260 1750 { lab=nb5}
N 2150 1800 2270 1800 { lab=b9}
N 2150 1820 2270 1820 { lab=nb8}
N 2150 1840 2270 1840 { lab=b7}
N 2150 1860 2270 1860 { lab=nb6}
N 2150 1880 2270 1880 { lab=b5}
N 2150 1960 2270 1960 { lab=b9}
N 2150 1980 2270 1980 { lab=nb8}
N 2150 2000 2270 2000 { lab=b7}
N 2160 2020 2270 2020 { lab=nb6}
N 2150 2040 2270 2040 { lab=nb5}
N 2150 2110 2270 2110 { lab=b9}
N 2150 2130 2270 2130 { lab=nb8}
N 2150 2150 2270 2150 { lab=nb7}
N 2150 2170 2270 2170 { lab=b6}
N 2150 2190 2270 2190 { lab=b5}
N 2150 2260 2260 2260 { lab=b9}
N 2150 2280 2260 2280 { lab=nb8}
N 2150 2300 2260 2300 { lab=nb7}
N 2150 2320 2260 2320 { lab=b6}
N 2150 2340 2260 2340 { lab=nb5}
N 2150 2430 2270 2430 { lab=b9}
N 2150 2450 2270 2450 { lab=nb8}
N 2150 2470 2270 2470 { lab=nb7}
N 2150 2490 2270 2490 { lab=nb6}
N 2150 2510 2270 2510 { lab=b5}
N 2150 2600 2260 2600 { lab=b9}
N 2150 2620 2260 2620 { lab=nb8}
N 2150 2640 2260 2640 { lab=nb7}
N 2150 2660 2260 2660 { lab=nb6}
N 2150 2680 2260 2680 { lab=nb5}
N 2150 2740 2260 2740 { lab=nb9}
N 2150 2760 2260 2760 { lab=b8}
N 2150 2780 2260 2780 { lab=b7}
N 2160 2800 2260 2800 { lab=b6}
N 2160 2820 2260 2820 { lab=b5}
N 2150 2800 2160 2800 { lab=b6}
N 2150 2820 2160 2820 { lab=b5}
N 2150 2880 2270 2880 { lab=nb9}
N 2150 2900 2270 2900 { lab=b8}
N 2150 2920 2270 2920 { lab=b7}
N 2150 2940 2270 2940 { lab=b6}
N 2160 2960 2270 2960 { lab=nb5}
N 2150 2960 2160 2960 { lab=nb5}
N 2160 3020 2260 3020 { lab=nb9}
N 2150 3040 2260 3040 { lab=b8}
N 2150 3060 2260 3060 { lab=b7}
N 2150 3020 2160 3020 { lab=nb9}
N 2150 3080 2260 3080 { lab=nb6}
N 2150 3100 2260 3100 { lab=b5}
N 2150 3160 2270 3160 { lab=nb9}
N 2150 3180 2270 3180 { lab=b8}
N 2150 3200 2270 3200 { lab=b7}
N 2150 3220 2270 3220 { lab=nb6}
N 2150 3240 2270 3240 { lab=nb5}
N 2150 3300 2270 3300 { lab=nb9}
N 2150 3320 2270 3320 { lab=b8}
N 2150 3340 2270 3340 { lab=nb7}
N 2150 3360 2270 3360 { lab=b6}
N 2150 3380 2270 3380 { lab=b5}
N 2150 3440 2260 3440 { lab=nb9}
N 2150 3460 2260 3460 { lab=b8}
N 2150 3480 2260 3480 { lab=nb7}
N 2150 3500 2260 3500 { lab=b6}
N 2150 3520 2260 3520 { lab=nb5}
N 2160 3580 2260 3580 { lab=nb9}
N 2150 3580 2160 3580 { lab=nb9}
N 2150 3600 2260 3600 { lab=b8}
N 2150 3620 2260 3620 { lab=nb7}
N 2150 3640 2260 3640 { lab=nb6}
N 2150 3660 2260 3660 { lab=b5}
N 2150 3730 2260 3730 { lab=nb9}
N 2150 3750 2260 3750 { lab=b8}
N 2150 3770 2260 3770 { lab=nb7}
N 2150 3790 2260 3790 { lab=nb6}
N 2150 3810 2260 3810 { lab=nb5}
N 2150 3890 2270 3890 { lab=nb9}
N 2150 3910 2270 3910 { lab=nb8}
N 2150 3930 2270 3930 { lab=b7}
N 2150 3950 2270 3950 { lab=b6}
N 2150 3970 2270 3970 { lab=b5}
N 2150 4040 2270 4040 { lab=nb9}
N 2150 4060 2270 4060 { lab=nb8}
N 2150 4080 2270 4080 { lab=b7}
N 2150 4100 2270 4100 { lab=b6}
N 2150 4120 2270 4120 { lab=nb5}
N 2150 4180 2260 4180 { lab=nb9}
N 2150 4200 2260 4200 { lab=nb8}
N 2150 4220 2260 4220 { lab=b7}
N 2150 4240 2260 4240 { lab=nb6}
N 2150 4260 2260 4260 { lab=b5}
N 2150 4320 2270 4320 { lab=nb9}
N 2150 4340 2270 4340 { lab=nb8}
N 2150 4360 2270 4360 { lab=b7}
N 2150 4380 2270 4380 { lab=nb6}
N 2150 4400 2270 4400 { lab=nb5}
N 2150 4460 2260 4460 { lab=nb9}
N 2150 4480 2260 4480 { lab=nb8}
N 2150 4500 2260 4500 { lab=nb7}
N 2150 4520 2260 4520 { lab=b6}
N 2150 4540 2260 4540 { lab=b5}
N 2150 4590 2270 4590 { lab=nb9}
N 2150 4610 2270 4610 { lab=nb8}
N 2150 4630 2270 4630 { lab=nb7}
N 2150 4650 2270 4650 { lab=b6}
N 2150 4670 2270 4670 { lab=nb5}
N 2150 4710 2270 4710 { lab=nb9}
N 2150 4730 2270 4730 { lab=nb8}
N 2150 4750 2270 4750 { lab=nb7}
N 2150 4770 2270 4770 { lab=nb6}
N 2150 4790 2270 4790 { lab=b5}
N 2150 4840 2260 4840 { lab=nb9}
N 2150 4860 2260 4860 { lab=nb8}
N 2150 4880 2260 4880 { lab=nb7}
N 2150 4900 2260 4900 { lab=nb6}
N 2150 4920 2260 4920 { lab=nb5}
N 2150 2020 2160 2020 { lab=nb6}
N 2910 400 2910 410 { lab=#net1}
N 2900 570 2900 580 { lab=#net3}
N 2900 730 2900 740 { lab=#net5}
N 2910 870 2910 880 { lab=#net7}
N 2910 1010 2910 1020 { lab=#net9}
N 2910 1140 2910 1150 { lab=#net11}
N 2910 1270 2910 1280 { lab=#net13}
N 2910 1400 2910 1410 { lab=#net15}
N 2910 1540 2910 1550 { lab=#net17}
N 2900 1680 2900 1690 { lab=#net19}
N 2910 1810 2910 1820 { lab=#net21}
N 2910 1970 2910 1980 { lab=#net23}
N 2910 2120 2910 2130 { lab=#net25}
N 2910 2270 2910 2280 { lab=#net27}
N 2910 2440 2910 2450 { lab=#net29}
N 2910 2610 2910 2620 { lab=#net31}
N 2910 2750 2910 2760 { lab=#net33}
N 2920 2890 2920 2900 { lab=#net35}
N 2910 3030 2910 3040 { lab=#net37}
N 2910 3170 2910 3180 { lab=#net39}
N 2910 3310 2910 3320 { lab=#net41}
N 2910 3450 2910 3460 { lab=#net43}
N 2910 3590 2910 3600 { lab=#net45}
N 2910 3740 2910 3750 { lab=#net47}
N 2920 3900 2920 3910 { lab=#net49}
N 2930 4050 2930 4060 { lab=#net51}
N 2930 4190 2930 4200 { lab=#net53}
N 2930 4330 2930 4340 { lab=#net55}
N 2930 4470 2930 4480 { lab=#net57}
N 2930 4600 2930 4610 { lab=#net59}
N 2930 4850 2930 4860 { lab=#net63}
N 2930 4720 2930 4730 { lab=#net61}
N 3230 4890 3540 4890 { lab=GND}
N 3540 4630 3540 4890 { lab=GND}
N 3540 4370 3540 4630 { lab=GND}
N 3230 4370 3540 4370 { lab=GND}
N 3230 4510 3540 4510 { lab=GND}
N 3230 4640 3540 4640 { lab=GND}
N 3230 4230 3540 4230 { lab=GND}
N 3540 4230 3540 4370 { lab=GND}
N 3210 440 3500 440 { lab=GND}
N 3500 440 3530 440 { lab=GND}
N 3200 610 3540 610 { lab=GND}
N 3540 440 3540 610 { lab=GND}
N 3530 440 3540 440 { lab=GND}
N 3540 4090 3540 4230 { lab=GND}
N 3230 4090 3540 4090 { lab=GND}
N 3540 3940 3540 4090 { lab=GND}
N 3220 3940 3540 3940 { lab=GND}
N 3540 3780 3540 3940 { lab=GND}
N 3210 3780 3540 3780 { lab=GND}
N 3210 3630 3540 3630 { lab=GND}
N 3540 3630 3540 3780 { lab=GND}
N 3980 4890 3980 4960 { lab=GND}
N 3540 4960 3980 4960 { lab=GND}
N 3540 4890 3540 4960 { lab=GND}
N 3980 4960 3980 4980 { lab=GND}
N 3980 4980 4250 4980 { lab=GND}
N 4250 4760 4250 4980 { lab=GND}
N 3980 4760 4020 4760 { lab=GND}
N 4020 4750 4020 4760 { lab=GND}
N 4020 4750 4250 4750 { lab=GND}
N 4250 4750 4250 4760 { lab=GND}
N 3210 3490 3540 3490 { lab=GND}
N 3540 3490 3540 3630 { lab=GND}
N 3210 3350 3540 3350 { lab=GND}
N 3540 3350 3540 3490 { lab=GND}
N 3210 3210 3540 3210 { lab=GND}
N 3540 3210 3540 3350 { lab=GND}
N 3210 3070 3540 3070 { lab=GND}
N 3540 3070 3540 3210 { lab=GND}
N 3220 2930 3530 2930 { lab=GND}
N 3530 2930 3540 2930 { lab=GND}
N 3540 2930 3540 3070 { lab=GND}
N 3210 2790 3540 2790 { lab=GND}
N 3540 2790 3540 2930 { lab=GND}
N 3210 2650 3540 2650 { lab=GND}
N 3540 2650 3540 2790 { lab=GND}
N 3210 2480 3540 2480 { lab=GND}
N 3540 2480 3540 2650 { lab=GND}
N 3210 2310 3540 2310 { lab=GND}
N 3540 2310 3540 2480 { lab=GND}
N 3210 2160 3540 2160 { lab=GND}
N 3540 2160 3540 2310 { lab=GND}
N 3210 2010 3540 2010 { lab=GND}
N 3540 2010 3540 2160 { lab=GND}
N 3210 1850 3540 1850 { lab=GND}
N 3540 1850 3540 2010 { lab=GND}
N 3200 1720 3540 1720 { lab=GND}
N 3540 1720 3540 1850 { lab=GND}
N 3210 1580 3540 1580 { lab=GND}
N 3540 1580 3540 1720 { lab=GND}
N 3210 1440 3540 1440 { lab=GND}
N 3540 1440 3540 1580 { lab=GND}
N 3210 1310 3530 1310 { lab=GND}
N 3530 1310 3540 1310 { lab=GND}
N 3540 1310 3540 1440 { lab=GND}
N 3210 1180 3540 1180 { lab=GND}
N 3540 1180 3540 1310 { lab=GND}
N 3210 1050 3540 1050 { lab=GND}
N 3540 1050 3540 1180 { lab=GND}
N 3210 910 3540 910 { lab=GND}
N 3540 910 3540 1050 { lab=GND}
N 3200 770 3540 770 { lab=GND}
N 3540 770 3540 910 { lab=GND}
N 3540 610 3540 770 { lab=GND}
N 2720 5000 3550 5000 { lab=GND}
N 3550 4960 3550 5000 { lab=GND}
N 2720 440 2720 5000 {lab=GND}
N 2530 450 2720 450 { lab=GND}
N 2540 390 2640 390 { lab=VDD}
N 2640 390 2640 4840 {lab=VDD}
N 2560 4840 2640 4840 { lab=VDD}
N 2530 560 2640 560 { lab=VDD}
N 2530 620 2720 620 { lab=GND}
N 2540 720 2640 720 { lab=VDD}
N 2540 780 2720 780 { lab=GND}
N 2540 860 2640 860 { lab=VDD}
N 2540 920 2720 920 { lab=GND}
N 2640 300 2640 390 {lab=VDD}
N 2530 390 2540 390 { lab=VDD}
N 2540 1000 2640 1000 { lab=VDD}
N 2540 1060 2720 1060 { lab=GND}
N 2550 1130 2640 1130 { lab=VDD}
N 2550 1190 2720 1190 { lab=GND}
N 2560 1260 2640 1260 { lab=VDD}
N 2560 1320 2720 1320 { lab=GND}
N 2560 1390 2640 1390 { lab=VDD}
N 2560 1450 2720 1450 { lab=GND}
N 2560 1530 2640 1530 { lab=VDD}
N 2560 1590 2720 1590 { lab=GND}
N 2560 1670 2640 1670 { lab=VDD}
N 2560 1730 2720 1730 { lab=GND}
N 2570 1800 2640 1800 { lab=VDD}
N 2570 1860 2720 1860 { lab=GND}
N 2570 1960 2640 1960 { lab=VDD}
N 2570 2020 2720 2020 { lab=GND}
N 2570 2110 2640 2110 { lab=VDD}
N 2570 2170 2720 2170 { lab=GND}
N 2560 2320 2720 2320 { lab=GND}
N 2560 2260 2640 2260 { lab=VDD}
N 2570 2430 2640 2430 { lab=VDD}
N 2570 2490 2720 2490 { lab=GND}
N 2560 2600 2640 2600 { lab=VDD}
N 2560 2660 2720 2660 { lab=GND}
N 2560 2740 2640 2740 { lab=VDD}
N 2560 2800 2720 2800 { lab=GND}
N 2570 2880 2640 2880 { lab=VDD}
N 2570 2940 2720 2940 { lab=GND}
N 2560 3020 2640 3020 { lab=VDD}
N 2560 3080 2720 3080 { lab=GND}
N 2570 3160 2640 3160 { lab=VDD}
N 2570 3220 2720 3220 { lab=GND}
N 2570 3300 2640 3300 { lab=VDD}
N 2570 3360 2720 3360 { lab=GND}
N 2560 3640 2720 3640 { lab=GND}
N 2560 3580 2640 3580 { lab=VDD}
N 2560 3440 2640 3440 { lab=VDD}
N 2560 3500 2720 3500 { lab=GND}
N 2560 3790 2720 3790 { lab=GND}
N 2560 3730 2640 3730 { lab=VDD}
N 2570 3890 2640 3890 { lab=VDD}
N 2570 3950 2720 3950 { lab=GND}
N 2570 4040 2640 4040 { lab=VDD}
N 2570 4100 2720 4100 { lab=GND}
N 2560 4180 2640 4180 { lab=VDD}
N 2560 4240 2720 4240 { lab=GND}
N 2570 4320 2640 4320 { lab=VDD}
N 2570 4380 2720 4380 { lab=GND}
N 2570 4650 2720 4650 { lab=GND}
N 2570 4590 2640 4590 { lab=VDD}
N 2570 4710 2640 4710 { lab=VDD}
N 2570 4770 2720 4770 { lab=GND}
N 2560 4900 2720 4900 { lab=GND}
N 4250 3820 4250 4750 { lab=GND}
N 4250 2240 4250 3820 { lab=GND}
N 4250 500 4250 2240 { lab=GND}
N 4250 440 4250 500 { lab=GND}
N 3930 440 4250 440 { lab=GND}
N 3920 610 4250 610 { lab=GND}
N 3930 770 4020 770 { lab=GND}
N 4020 760 4020 770 { lab=GND}
N 4020 760 4250 760 { lab=GND}
N 3930 910 4000 910 { lab=GND}
N 4000 900 4000 910 { lab=GND}
N 4000 900 4250 900 { lab=GND}
N 3930 1050 4000 1050 { lab=GND}
N 4000 1040 4000 1050 { lab=GND}
N 4000 1040 4250 1040 { lab=GND}
N 3930 1180 4250 1180 { lab=GND}
N 3930 1310 4250 1310 { lab=GND}
N 3940 1440 4250 1440 { lab=GND}
N 3940 1580 4250 1580 { lab=GND}
N 3950 1720 4250 1720 { lab=GND}
N 3940 1850 4250 1850 { lab=GND}
N 3950 2010 4250 2010 { lab=GND}
N 3950 2160 4250 2160 { lab=GND}
N 3950 2300 4250 2300 { lab=GND}
N 3960 2480 4250 2480 { lab=GND}
N 3960 2650 4250 2650 { lab=GND}
N 3960 2790 4250 2790 { lab=GND}
N 3960 2930 4020 2930 { lab=GND}
N 4020 2920 4020 2930 { lab=GND}
N 4020 2920 4250 2920 { lab=GND}
N 3990 3070 4250 3070 { lab=GND}
N 3970 3210 4250 3210 { lab=GND}
N 3970 3350 4250 3350 { lab=GND}
N 3970 3490 4250 3490 { lab=GND}
N 3980 3630 4250 3630 { lab=GND}
N 3980 3780 4250 3780 { lab=GND}
N 3980 3940 4250 3940 { lab=GND}
N 3980 4090 4020 4090 { lab=GND}
N 4020 4080 4020 4090 { lab=GND}
N 4020 4080 4250 4080 { lab=GND}
N 3980 4230 4020 4230 { lab=GND}
N 4020 4220 4020 4230 { lab=GND}
N 4020 4220 4250 4220 { lab=GND}
N 3980 4350 4250 4350 { lab=GND}
N 3980 4510 4020 4510 { lab=GND}
N 4020 4500 4020 4510 { lab=GND}
N 4020 4500 4250 4500 { lab=GND}
N 3980 4640 4020 4640 { lab=GND}
N 4020 4630 4020 4640 { lab=GND}
N 4020 4630 4250 4630 { lab=GND}
N 2910 430 2910 460 { lab=#net2}
N 2910 460 3630 460 { lab=#net2}
N 3630 430 3630 460 { lab=#net2}
N 2900 600 2900 630 { lab=#net4}
N 2900 630 3620 630 { lab=#net4}
N 3620 600 3620 630 { lab=#net4}
N 2900 760 2900 790 { lab=#net6}
N 2900 790 3630 790 { lab=#net6}
N 3630 760 3630 790 { lab=#net6}
N 2910 900 2910 940 { lab=#net8}
N 3630 900 3630 940 { lab=#net8}
N 2910 940 3630 940 { lab=#net8}
N 2910 1040 2910 1070 { lab=#net10}
N 2910 1070 3630 1070 { lab=#net10}
N 3630 1040 3630 1070 { lab=#net10}
N 2910 1170 2910 1200 { lab=#net12}
N 2910 1200 3430 1200 { lab=#net12}
N 3430 1200 3630 1200 { lab=#net12}
N 3630 1170 3630 1200 { lab=#net12}
N 2910 1300 2910 1330 { lab=#net14}
N 2910 1430 2910 1460 { lab=#net16}
N 2910 1460 3330 1460 { lab=#net16}
N 3330 1450 3640 1450 { lab=#net16}
N 2910 1590 3640 1590 { lab=#net18}
N 2900 1710 2900 1740 { lab=#net20}
N 2900 1740 3650 1740 { lab=#net20}
N 3650 1710 3650 1740 { lab=#net20}
N 2910 1840 2910 1880 { lab=#net22}
N 2910 1880 3640 1880 { lab=#net22}
N 3640 1840 3640 1880 { lab=#net22}
N 2910 2000 2910 2030 { lab=#net24}
N 2910 2030 3650 2030 { lab=#net24}
N 3650 2000 3650 2030 { lab=#net24}
N 2910 2150 2910 2180 { lab=#net26}
N 2910 2180 3650 2180 { lab=#net26}
N 3650 2150 3650 2180 { lab=#net26}
N 2910 2300 2910 2340 { lab=#net28}
N 2910 2340 3340 2340 { lab=#net28}
N 3340 2340 3650 2340 { lab=#net28}
N 3650 2290 3650 2340 { lab=#net28}
N 2910 2470 2910 2500 { lab=#net30}
N 2910 2500 3660 2500 { lab=#net30}
N 3660 2470 3660 2500 { lab=#net30}
N 2910 2640 2910 2670 { lab=#net32}
N 2910 2670 3660 2670 { lab=#net32}
N 3660 2640 3660 2670 { lab=#net32}
N 2910 2780 2910 2810 { lab=#net34}
N 2910 2810 3660 2810 { lab=#net34}
N 3660 2780 3660 2810 { lab=#net34}
N 2920 2920 2920 2950 { lab=#net36}
N 2920 2950 3660 2950 { lab=#net36}
N 3660 2920 3660 2950 { lab=#net36}
N 2910 3090 3690 3090 { lab=#net38}
N 2910 3200 2910 3230 { lab=#net40}
N 2910 3230 3390 3230 { lab=#net40}
N 3390 3230 3670 3230 { lab=#net40}
N 3670 3200 3670 3230 { lab=#net40}
N 2910 3340 2910 3370 { lab=#net42}
N 2910 3370 3280 3370 { lab=#net42}
N 3280 3370 3670 3370 { lab=#net42}
N 3670 3340 3670 3370 { lab=#net42}
N 3670 3480 3670 3500 { lab=#net44}
N 3200 3500 3670 3500 { lab=#net44}
N 3200 3500 3200 3510 { lab=#net44}
N 2910 3510 3200 3510 { lab=#net44}
N 2910 3480 2910 3510 { lab=#net44}
N 2910 3620 2910 3650 { lab=#net46}
N 2910 3650 3410 3650 { lab=#net46}
N 3410 3650 3680 3650 { lab=#net46}
N 3680 3620 3680 3650 { lab=#net46}
N 2910 3770 2910 3800 { lab=#net48}
N 2910 3800 3680 3800 { lab=#net48}
N 3680 3770 3680 3800 { lab=#net48}
N 2920 3930 2920 3960 { lab=#net50}
N 2920 3960 3680 3960 { lab=#net50}
N 3680 3930 3680 3960 { lab=#net50}
N 2930 4080 2930 4110 { lab=#net52}
N 2930 4110 3680 4110 { lab=#net52}
N 3680 4080 3680 4110 { lab=#net52}
N 2930 4220 2930 4250 { lab=#net54}
N 2930 4250 3680 4250 { lab=#net54}
N 3680 4220 3680 4250 { lab=#net54}
N 2930 4360 2930 4390 { lab=#net56}
N 2930 4390 3670 4390 { lab=#net56}
N 3670 4390 3680 4390 { lab=#net56}
N 3680 4340 3680 4390 { lab=#net56}
N 2930 4500 2930 4530 { lab=#net58}
N 2930 4530 3680 4530 { lab=#net58}
N 3680 4500 3680 4530 { lab=#net58}
N 2930 4630 2930 4660 { lab=#net60}
N 2930 4660 3310 4660 { lab=#net60}
N 3310 4650 3310 4660 { lab=#net60}
N 3310 4650 3680 4650 { lab=#net60}
N 3680 4630 3680 4650 { lab=#net60}
N 2930 4750 2930 4780 { lab=#net62}
N 2930 4780 3680 4780 { lab=#net62}
N 3680 4750 3680 4780 { lab=#net62}
N 3230 4760 3540 4760 { lab=GND}
N 2930 4880 2930 4920 { lab=#net64}
N 2930 4920 3680 4920 { lab=#net64}
N 3680 4880 3680 4920 { lab=#net64}
N 2900 480 2900 570 { lab=#net3}
N 2900 480 3620 480 { lab=#net3}
N 3620 480 3620 570 { lab=#net3}
N 2910 320 2910 400 { lab=#net1}
N 2910 320 3630 320 { lab=#net1}
N 3630 320 3630 400 { lab=#net1}
N 2900 650 2900 730 { lab=#net5}
N 2900 650 3620 650 { lab=#net5}
N 3620 650 3630 650 { lab=#net5}
N 3630 650 3630 730 { lab=#net5}
N 2910 810 2910 870 { lab=#net7}
N 2910 810 3290 810 { lab=#net7}
N 3290 810 3340 810 { lab=#net7}
N 3340 800 3340 810 { lab=#net7}
N 3340 800 3390 800 { lab=#net7}
N 3390 800 3630 800 { lab=#net7}
N 3630 800 3630 870 { lab=#net7}
N 2910 950 2910 1010 { lab=#net9}
N 2910 950 3340 950 { lab=#net9}
N 3340 920 3340 950 { lab=#net9}
N 3340 920 3390 920 { lab=#net9}
N 3390 920 3390 950 { lab=#net9}
N 3390 950 3630 950 { lab=#net9}
N 3630 950 3630 1010 { lab=#net9}
N 2910 1080 2910 1140 { lab=#net11}
N 2910 1080 3340 1080 { lab=#net11}
N 3340 1060 3340 1080 { lab=#net11}
N 3340 1060 3400 1060 { lab=#net11}
N 3400 1060 3400 1080 { lab=#net11}
N 3400 1080 3630 1080 { lab=#net11}
N 3630 1080 3630 1140 { lab=#net11}
N 2910 1330 3200 1330 { lab=#net14}
N 3200 1320 3200 1330 { lab=#net14}
N 3200 1320 3630 1320 { lab=#net14}
N 3630 1300 3630 1320 { lab=#net14}
N 3640 1430 3640 1450 { lab=#net16}
N 3330 1450 3330 1460 { lab=#net16}
N 2910 1570 2910 1590 { lab=#net18}
N 3640 1570 3640 1590 { lab=#net18}
N 2910 1210 2910 1270 { lab=#net13}
N 2910 1210 3340 1210 { lab=#net13}
N 3340 1190 3340 1210 { lab=#net13}
N 3340 1190 3410 1190 { lab=#net13}
N 3410 1190 3410 1220 { lab=#net13}
N 3410 1220 3620 1220 { lab=#net13}
N 3620 1220 3620 1270 { lab=#net13}
N 3620 1270 3630 1270 { lab=#net13}
N 2910 1340 2910 1400 { lab=#net15}
N 2910 1340 3260 1340 { lab=#net15}
N 3260 1340 3340 1340 { lab=#net15}
N 3340 1330 3340 1340 { lab=#net15}
N 3340 1330 3630 1330 { lab=#net15}
N 3630 1330 3640 1330 { lab=#net15}
N 3640 1330 3640 1400 { lab=#net15}
N 2910 1470 2910 1540 { lab=#net17}
N 2910 1470 3640 1470 { lab=#net17}
N 3640 1470 3640 1540 { lab=#net17}
N 3650 1610 3650 1680 { lab=#net19}
N 2900 1610 3650 1610 { lab=#net19}
N 2900 1610 2900 1680 { lab=#net19}
N 2910 1750 2910 1810 { lab=#net21}
N 2910 1750 3330 1750 { lab=#net21}
N 3330 1730 3330 1750 { lab=#net21}
N 3330 1730 3410 1730 { lab=#net21}
N 3410 1730 3410 1760 { lab=#net21}
N 3410 1760 3640 1760 { lab=#net21}
N 3640 1760 3640 1810 { lab=#net21}
N 2910 1900 2910 1970 { lab=#net23}
N 2910 1900 3650 1900 { lab=#net23}
N 3650 1900 3650 1970 { lab=#net23}
N 3650 2050 3650 2120 { lab=#net25}
N 2910 2050 3650 2050 { lab=#net25}
N 2910 2050 2910 2120 { lab=#net25}
N 2910 2190 2910 2270 { lab=#net27}
N 2910 2190 3650 2190 { lab=#net27}
N 3650 2190 3650 2260 { lab=#net27}
N 3660 2360 3660 2440 { lab=#net29}
N 2910 2360 3660 2360 { lab=#net29}
N 2910 2360 2910 2440 { lab=#net29}
N 2910 2520 2910 2610 { lab=#net31}
N 2910 2520 3660 2520 { lab=#net31}
N 3660 2520 3660 2610 { lab=#net31}
N 3660 2680 3660 2750 { lab=#net33}
N 2910 2680 2910 2750 { lab=#net33}
N 2910 2680 3660 2680 { lab=#net33}
N 3660 2820 3660 2890 { lab=#net35}
N 3170 2820 3660 2820 { lab=#net35}
N 2920 2820 3170 2820 { lab=#net35}
N 2920 2820 2920 2890 { lab=#net35}
N 2910 2960 2910 3030 { lab=#net37}
N 2910 2960 3420 2960 { lab=#net37}
N 3420 2960 3690 2960 { lab=#net37}
N 3690 2960 3690 3030 { lab=#net37}
N 3670 3110 3670 3170 { lab=#net39}
N 3690 3060 3690 3090 { lab=#net38}
N 3670 3100 3670 3110 { lab=#net39}
N 3130 3100 3670 3100 { lab=#net39}
N 2910 3100 3130 3100 { lab=#net39}
N 2910 3100 2910 3170 { lab=#net39}
N 2910 3060 2910 3090 { lab=#net38}
N 2910 3240 2910 3310 { lab=#net41}
N 2910 3240 3410 3240 { lab=#net41}
N 3410 3240 3670 3240 { lab=#net41}
N 3670 3240 3670 3310 { lab=#net41}
N 3670 3380 3670 3450 { lab=#net43}
N 3230 3380 3670 3380 { lab=#net43}
N 2910 3380 3230 3380 { lab=#net43}
N 2910 3380 2910 3450 { lab=#net43}
N 2910 3520 2910 3590 { lab=#net45}
N 2910 3520 3680 3520 { lab=#net45}
N 3680 3520 3680 3590 { lab=#net45}
N 2910 3660 2910 3740 { lab=#net47}
N 2910 3660 3400 3660 { lab=#net47}
N 3400 3660 3680 3660 { lab=#net47}
N 3680 3660 3680 3740 { lab=#net47}
N 3680 3820 3680 3900 { lab=#net49}
N 2920 3820 3680 3820 { lab=#net49}
N 2920 3820 2920 3900 { lab=#net49}
N 2930 3980 2930 4050 { lab=#net51}
N 2930 3980 3680 3980 { lab=#net51}
N 3680 3980 3680 4050 { lab=#net51}
N 3680 4140 3680 4190 { lab=#net53}
N 3400 4140 3680 4140 { lab=#net53}
N 3400 4100 3400 4140 { lab=#net53}
N 3300 4100 3400 4100 { lab=#net53}
N 3300 4100 3300 4130 { lab=#net53}
N 2930 4130 3300 4130 { lab=#net53}
N 2930 4130 2930 4190 { lab=#net53}
N 2930 4260 2930 4330 { lab=#net55}
N 2930 4260 3410 4260 { lab=#net55}
N 3410 4260 3680 4260 { lab=#net55}
N 3680 4260 3680 4310 { lab=#net55}
N 3680 4410 3680 4470 { lab=#net57}
N 3390 4410 3680 4410 { lab=#net57}
N 3390 4380 3390 4410 { lab=#net57}
N 3300 4380 3390 4380 { lab=#net57}
N 3300 4380 3300 4400 { lab=#net57}
N 3300 4400 3300 4410 { lab=#net57}
N 2930 4410 3300 4410 { lab=#net57}
N 2930 4410 2930 4470 { lab=#net57}
N 2930 4540 2930 4600 { lab=#net59}
N 2930 4540 3320 4540 { lab=#net59}
N 3320 4520 3320 4540 { lab=#net59}
N 3320 4520 3400 4520 { lab=#net59}
N 3400 4520 3400 4550 { lab=#net59}
N 3400 4550 3680 4550 { lab=#net59}
N 3680 4550 3680 4600 { lab=#net59}
N 3680 4670 3680 4720 { lab=#net61}
N 3390 4670 3680 4670 { lab=#net61}
N 3390 4630 3390 4670 { lab=#net61}
N 3290 4630 3390 4630 { lab=#net61}
N 3290 4630 3290 4670 { lab=#net61}
N 2930 4670 3290 4670 { lab=#net61}
N 2930 4670 2930 4720 { lab=#net61}
N 2930 4790 2930 4850 { lab=#net63}
N 2930 4790 3330 4790 { lab=#net63}
N 3330 4770 3330 4790 { lab=#net63}
N 3330 4770 3400 4770 { lab=#net63}
N 3400 4770 3400 4790 { lab=#net63}
N 3400 4790 3680 4790 { lab=#net63}
N 3680 4790 3680 4850 { lab=#net63}
N 440 180 510 180 { lab=VDD}
N 510 150 510 180 { lab=VDD}
N 440 150 510 150 { lab=VDD}
N 440 210 440 280 { lab=nb9}
N 440 310 510 310 { lab=GND}
N 510 310 510 340 { lab=GND}
N 440 340 510 340 { lab=GND}
N 400 180 400 310 { lab=b9}
N 440 240 500 240 { lab=nb9}
N 330 210 330 220 { lab=b9}
N 330 210 400 210 { lab=b9}
N 720 180 790 180 { lab=VDD}
N 790 150 790 180 { lab=VDD}
N 720 150 790 150 { lab=VDD}
N 720 210 720 280 { lab=nb8}
N 720 310 790 310 { lab=GND}
N 790 310 790 340 { lab=GND}
N 720 340 790 340 { lab=GND}
N 680 180 680 310 { lab=b8}
N 720 240 780 240 { lab=nb8}
N 980 180 1050 180 { lab=VDD}
N 1050 150 1050 180 { lab=VDD}
N 980 150 1050 150 { lab=VDD}
N 980 210 980 280 { lab=nb7}
N 980 310 1050 310 { lab=GND}
N 1050 310 1050 340 { lab=GND}
N 980 340 1050 340 { lab=GND}
N 940 180 940 310 { lab=b7}
N 980 240 1040 240 { lab=nb7}
N 1240 180 1310 180 { lab=VDD}
N 1310 150 1310 180 { lab=VDD}
N 1240 150 1310 150 { lab=VDD}
N 1240 210 1240 280 { lab=nb6}
N 1240 310 1310 310 { lab=GND}
N 1310 310 1310 340 { lab=GND}
N 1240 340 1310 340 { lab=GND}
N 1200 180 1200 310 { lab=b6}
N 1240 240 1300 240 { lab=nb6}
N 1490 180 1560 180 { lab=VDD}
N 1560 150 1560 180 { lab=VDD}
N 1490 150 1560 150 { lab=VDD}
N 1490 210 1490 280 { lab=nb5}
N 1490 310 1560 310 { lab=GND}
N 1560 310 1560 340 { lab=GND}
N 1490 340 1560 340 { lab=GND}
N 1450 180 1450 310 { lab=b5}
N 1490 240 1550 240 { lab=nb5}
N 430 460 500 460 { lab=VDD}
N 500 430 500 460 { lab=VDD}
N 430 430 500 430 { lab=VDD}
N 430 490 430 560 { lab=nb4}
N 430 590 500 590 { lab=GND}
N 500 590 500 620 { lab=GND}
N 430 620 500 620 { lab=GND}
N 390 460 390 590 { lab=b4}
N 430 520 490 520 { lab=nb4}
N 720 460 790 460 { lab=VDD}
N 790 430 790 460 { lab=VDD}
N 720 430 790 430 { lab=VDD}
N 720 490 720 560 { lab=nb3}
N 720 590 790 590 { lab=GND}
N 790 590 790 620 { lab=GND}
N 720 620 790 620 { lab=GND}
N 680 460 680 590 { lab=b3}
N 720 520 780 520 { lab=nb3}
N 980 460 1050 460 { lab=VDD}
N 1050 430 1050 460 { lab=VDD}
N 980 430 1050 430 { lab=VDD}
N 980 490 980 560 { lab=nb2}
N 980 590 1050 590 { lab=GND}
N 1050 590 1050 620 { lab=GND}
N 980 620 1050 620 { lab=GND}
N 940 460 940 590 { lab=b2}
N 980 520 1040 520 { lab=nb2}
N 1250 460 1320 460 { lab=VDD}
N 1320 430 1320 460 { lab=VDD}
N 1250 430 1320 430 { lab=VDD}
N 1250 490 1250 560 { lab=nb1}
N 1250 590 1320 590 { lab=GND}
N 1320 590 1320 620 { lab=GND}
N 1250 620 1320 620 { lab=GND}
N 1210 460 1210 590 { lab=b1}
N 1250 520 1310 520 { lab=nb1}
N 1500 460 1570 460 { lab=VDD}
N 1570 430 1570 460 { lab=VDD}
N 1500 430 1570 430 { lab=VDD}
N 1500 490 1500 560 { lab=nb0}
N 1500 590 1570 590 { lab=GND}
N 1570 590 1570 620 { lab=GND}
N 1500 620 1570 620 { lab=GND}
N 1460 460 1460 590 { lab=b0}
N 1500 520 1560 520 { lab=nb0}
N 620 230 620 240 { lab=b8}
N 620 230 680 230 { lab=b8}
N 870 220 870 230 { lab=b7}
N 870 220 940 220 { lab=b7}
N 1140 210 1140 220 { lab=b6}
N 1140 210 1200 210 { lab=b6}
N 1390 210 1390 220 { lab=b5}
N 1390 210 1450 210 { lab=b5}
N 310 490 310 500 { lab=b4}
N 310 490 390 490 { lab=b4}
N 610 500 610 510 { lab=b3}
N 610 500 680 500 { lab=b3}
N 870 490 870 500 { lab=b2}
N 870 490 940 490 { lab=b2}
N 1140 480 1140 490 { lab=b1}
N 1140 480 1210 480 { lab=b1}
N 1400 500 1400 510 { lab=b0}
N 1400 500 1460 500 { lab=b0}
N 330 280 330 340 { lab=GND}
N 330 340 440 340 { lab=GND}
N 620 300 620 340 { lab=GND}
N 620 340 720 340 { lab=GND}
N 870 290 870 340 { lab=GND}
N 870 340 980 340 { lab=GND}
N 1140 280 1140 340 { lab=GND}
N 1140 340 1240 340 { lab=GND}
N 1390 280 1390 340 { lab=GND}
N 1390 340 1490 340 { lab=GND}
N 1400 570 1400 620 { lab=GND}
N 1400 620 1500 620 { lab=GND}
N 1140 550 1140 620 { lab=GND}
N 1140 620 1250 620 { lab=GND}
N 870 560 870 620 { lab=GND}
N 870 620 980 620 { lab=GND}
N 610 570 610 620 { lab=GND}
N 610 620 720 620 { lab=GND}
N 310 560 310 620 { lab=GND}
N 310 620 430 620 { lab=GND}
N 280 210 330 210 { lab=b9}
N 610 230 620 230 { lab=b8}
N 850 220 870 220 { lab=b7}
N 1120 210 1140 210 { lab=b6}
N 1380 210 1390 210 { lab=b5}
N 1390 500 1400 500 { lab=b0}
N 1130 480 1140 480 { lab=b1}
N 860 490 870 490 { lab=b2}
N 600 500 610 500 { lab=b3}
N 300 490 310 490 { lab=b4}
N 1500 400 1500 430 { lab=VDD}
N 1490 120 1490 150 { lab=VDD}
N 1240 120 1240 150 { lab=VDD}
N 980 120 980 150 { lab=VDD}
N 720 120 720 150 { lab=VDD}
N 440 120 440 150 { lab=VDD}
N 430 400 430 430 { lab=VDD}
N 720 390 720 430 { lab=VDD}
N 980 390 980 430 { lab=VDD}
N 1250 390 1250 430 { lab=VDD}
N 1860 90 1860 140 { lab=pVref}
N 2020 210 2020 260 { lab=nVref}
N 1700 120 1700 170 { lab=GND}
N 1860 200 1860 240 { lab=GND}
N 2020 90 2020 150 { lab=GND}
N 1750 60 1750 80 { lab=VDD}
N 5490 4330 5540 4330 { lab=#net127}
N 5540 4150 5540 4270 { lab=#net128}
N 5490 4150 5540 4150 { lab=#net128}
N 5540 3970 5540 4090 { lab=#net129}
N 5500 3970 5540 3970 { lab=#net129}
N 5540 3790 5540 3910 { lab=#net130}
N 5490 3790 5540 3790 { lab=#net130}
N 5540 3630 5540 3730 { lab=#net131}
N 5490 3630 5540 3630 { lab=#net131}
N 5540 3480 5540 3570 { lab=#net132}
N 5490 3490 5540 3490 { lab=#net132}
N 5540 3320 5540 3420 { lab=#net133}
N 5490 3320 5540 3320 { lab=#net133}
N 5540 3140 5540 3260 { lab=#net134}
N 5410 3140 5470 3140 { lab=#net134}
N 5540 2900 5540 3080 { lab=#net135}
N 5500 2900 5540 2900 { lab=#net135}
N 5540 2720 5540 2840 { lab=#net136}
N 5500 2720 5540 2720 { lab=#net136}
N 5540 2540 5540 2660 { lab=#net137}
N 5510 2540 5540 2540 { lab=#net137}
N 5540 2360 5540 2480 { lab=#net138}
N 5500 2360 5540 2360 { lab=#net138}
N 5540 2200 5540 2300 { lab=#net139}
N 5500 2200 5540 2200 { lab=#net139}
N 5540 2060 5540 2140 { lab=#net140}
N 5500 2060 5540 2060 { lab=#net140}
N 5540 1880 5540 2000 { lab=#net141}
N 5500 1890 5540 1890 { lab=#net141}
N 5540 1710 5540 1820 { lab=#net142}
N 5490 1710 5540 1710 { lab=#net142}
N 5540 1500 5540 1650 { lab=#net143}
N 5500 1500 5540 1500 { lab=#net143}
N 5540 1320 5540 1440 { lab=#net144}
N 5490 1320 5540 1320 { lab=#net144}
N 5560 1310 5560 1320 { lab=#net144}
N 5540 1320 5560 1320 { lab=#net144}
N 5520 1140 5560 1140 { lab=#net145}
N 5560 1140 5560 1250 { lab=#net145}
N 5560 960 5560 1080 { lab=#net146}
N 5510 960 5560 960 { lab=#net146}
N 5560 800 5560 900 { lab=#net147}
N 5510 800 5560 800 { lab=#net147}
N 5560 660 5560 740 { lab=#net148}
N 5510 660 5560 660 { lab=#net148}
N 5560 490 5560 600 { lab=#net149}
N 5510 490 5560 490 { lab=#net149}
N 5560 310 5560 430 { lab=#net150}
N 5500 310 5560 310 { lab=#net150}
N 5510 680 5640 680 { lab=Out}
N 5510 820 5640 820 { lab=Out}
N 5510 980 5640 980 { lab=Out}
N 5520 1160 5640 1160 { lab=Out}
N 5510 510 5680 510 { lab=Out}
N 5680 320 5680 530 { lab=Out}
N 5640 680 5680 680 { lab=Out}
N 5680 530 5680 800 { lab=Out}
N 5640 820 5680 820 { lab=Out}
N 5680 800 5680 980 { lab=Out}
N 5640 980 5680 980 { lab=Out}
N 5680 980 5680 1030 { lab=Out}
N 5680 1030 5680 1370 { lab=Out}
N 5640 1160 5680 1160 { lab=Out}
N 5490 1340 5680 1340 { lab=Out}
N 5680 1370 5680 1830 { lab=Out}
N 5500 1520 5680 1520 { lab=Out}
N 5500 1910 5680 1910 { lab=Out}
N 5680 1830 5680 2110 { lab=Out}
N 5500 2080 5680 2080 { lab=Out}
N 5500 2220 5680 2220 { lab=Out}
N 5680 2110 5680 2420 { lab=Out}
N 5500 2380 5680 2380 { lab=Out}
N 5680 2420 5680 2800 { lab=Out}
N 5510 2560 5680 2560 { lab=Out}
N 5500 2740 5680 2740 { lab=Out}
N 5680 2800 5680 3180 { lab=Out}
N 5500 2920 5680 2920 { lab=Out}
N 5410 3160 5610 3160 { lab=Out}
N 5680 3180 5680 3700 { lab=Out}
N 5490 3340 5680 3340 { lab=Out}
N 5490 3510 5680 3510 { lab=Out}
N 5490 3650 5680 3650 { lab=Out}
N 5680 3700 5680 3840 { lab=Out}
N 5490 3810 5680 3810 { lab=Out}
N 5680 3840 5680 4070 { lab=Out}
N 5500 3990 5680 3990 { lab=Out}
N 5680 4070 5680 4250 { lab=Out}
N 5490 4170 5680 4170 { lab=Out}
N 5680 4250 5680 4350 { lab=Out}
N 5490 4350 5690 4350 { lab=Out}
N 5490 1730 5680 1730 { lab=Out}
N 5060 230 5490 230 { lab=MSB1_out}
N 5680 4350 5680 4490 { lab=Out}
N 5540 4330 5540 4410 { lab=#net127}
N 5540 4470 5540 4490 { lab=#net151}
N 5680 4490 5680 4580 { lab=Out}
N 5490 4490 5540 4490 { lab=#net151}
N 5540 4490 5540 4570 { lab=#net151}
N 5490 4650 5540 4650 { lab=#net152}
N 5540 4630 5540 4710 { lab=#net152}
N 5490 4790 5540 4790 { lab=#net153}
N 5540 4770 5540 4790 { lab=#net153}
N 5490 4930 5540 4930 { lab=#net154}
N 5540 4790 5540 4870 { lab=#net153}
N 5490 5090 5540 5090 { lab=#net155}
N 5540 4930 5540 5030 { lab=#net154}
N 5540 5090 5540 5180 { lab=#net155}
N 5490 5240 5540 5240 { lab=#net156}
N 5540 5240 5540 5340 { lab=#net156}
N 5500 5400 5540 5400 { lab=#net157}
N 5510 5560 5540 5560 { lab=MSB2_out}
N 5540 5400 5540 5500 { lab=#net157}
N 5490 4510 5680 4510 { lab=Out}
N 5680 4580 5680 4870 { lab=Out}
N 5490 4670 5680 4670 { lab=Out}
N 5490 4810 5680 4810 { lab=Out}
N 5680 4870 5680 5180 { lab=Out}
N 5490 4950 5680 4950 { lab=Out}
N 5490 5110 5680 5110 { lab=Out}
N 5680 5180 5680 5520 { lab=Out}
N 5490 5260 5680 5260 { lab=Out}
N 5500 5420 5680 5420 { lab=Out}
N 5510 5580 5680 5580 { lab=Out}
N 5680 5520 5680 5590 { lab=Out}
N 5070 5660 5470 5660 { lab=MSB2_out}
N 5500 330 5680 330 { lab=Out}
N 5030 290 5130 290 { lab=b4}
N 5030 310 5130 310 { lab=b3}
N 5030 370 5130 370 { lab=b0}
N 5040 470 5140 470 { lab=b4}
N 5030 490 5140 490 { lab=b3}
N 5030 470 5040 470 { lab=b4}
N 5030 510 5140 510 { lab=b2}
N 5030 530 5140 530 { lab=b1}
N 5030 550 5140 550 { lab=nb0}
N 5030 330 5130 330 { lab=b2}
N 5030 350 5130 350 { lab=b1}
N 5030 640 5140 640 { lab=b4}
N 5030 660 5140 660 { lab=b3}
N 5030 680 5140 680 { lab=b2}
N 5030 700 5140 700 { lab=nb1}
N 5030 720 5140 720 { lab=b0}
N 5030 780 5140 780 { lab=b4}
N 5030 800 5140 800 { lab=b3}
N 5030 820 5140 820 { lab=b2}
N 5030 840 5140 840 { lab=nb1}
N 5030 860 5140 860 { lab=nb0}
N 5030 940 5140 940 { lab=b4}
N 5030 960 5140 960 { lab=b3}
N 5030 980 5140 980 { lab=nb2}
N 5030 1000 5140 1000 { lab=b1}
N 5030 1020 5140 1020 { lab=b0}
N 5030 1120 5150 1120 { lab=b4}
N 5030 1140 5150 1140 { lab=b3}
N 5040 1160 5150 1160 { lab=nb2}
N 5030 1160 5040 1160 { lab=nb2}
N 5030 1180 5150 1180 { lab=b1}
N 5030 1200 5150 1200 { lab=nb0}
N 5030 1300 5120 1300 { lab=b4}
N 5030 1320 5120 1320 { lab=b3}
N 5030 1340 5120 1340 { lab=nb2}
N 5030 1360 5120 1360 { lab=nb1}
N 5030 1380 5120 1380 { lab=b0}
N 5030 1480 5130 1480 { lab=b4}
N 5030 1500 5130 1500 { lab=b3}
N 5030 1520 5130 1520 { lab=nb2}
N 5030 1540 5130 1540 { lab=nb1}
N 5030 1560 5130 1560 { lab=nb0}
N 5030 1690 5120 1690 { lab=b4}
N 5030 1710 5120 1710 { lab=nb3}
N 5030 1730 5120 1730 { lab=b2}
N 5030 1750 5120 1750 { lab=b1}
N 5030 1770 5120 1770 { lab=b0}
N 5030 1870 5130 1870 { lab=b4}
N 5030 1890 5130 1890 { lab=nb3}
N 5030 1910 5130 1910 { lab=b2}
N 5030 1930 5130 1930 { lab=b1}
N 5030 1950 5130 1950 { lab=nb0}
N 5030 2040 5130 2040 { lab=b4}
N 5030 2060 5130 2060 { lab=nb3}
N 5030 2080 5130 2080 { lab=b2}
N 5030 2100 5130 2100 { lab=nb1}
N 5030 2120 5130 2120 { lab=b0}
N 5030 2180 5130 2180 { lab=b4}
N 5030 2200 5130 2200 { lab=nb3}
N 5030 2220 5130 2220 { lab=b2}
N 5030 2240 5130 2240 { lab=nb1}
N 5030 2260 5130 2260 { lab=nb0}
N 5030 2340 5130 2340 { lab=b4}
N 5030 2360 5130 2360 { lab=nb3}
N 5030 2380 5130 2380 { lab=nb2}
N 5030 2400 5130 2400 { lab=b1}
N 5030 2420 5130 2420 { lab=b0}
N 5040 2520 5140 2520 { lab=b4}
N 5030 2540 5140 2540 { lab=nb3}
N 5030 2520 5040 2520 { lab=b4}
N 5030 2560 5140 2560 { lab=nb2}
N 5040 2580 5140 2580 { lab=b1}
N 5030 2580 5040 2580 { lab=b1}
N 5030 2600 5140 2600 { lab=nb0}
N 5030 2700 5130 2700 { lab=b4}
N 5030 2720 5130 2720 { lab=nb3}
N 5030 2740 5130 2740 { lab=nb2}
N 5030 2760 5130 2760 { lab=nb1}
N 5030 2780 5130 2780 { lab=b0}
N 5030 2880 5130 2880 { lab=b4}
N 5030 2900 5130 2900 { lab=nb3}
N 5030 2920 5130 2920 { lab=nb2}
N 5030 2940 5130 2940 { lab=nb1}
N 5030 2960 5130 2960 { lab=nb0}
N 5030 3120 5110 3120 { lab=nb4}
N 5030 3140 5110 3140 { lab=b3}
N 5030 3160 5110 3160 { lab=b2}
N 5030 3180 5110 3180 { lab=b1}
N 5030 3200 5110 3200 { lab=b0}
N 5030 3300 5120 3300 { lab=nb4}
N 5030 3320 5120 3320 { lab=b3}
N 5030 3340 5120 3340 { lab=b2}
N 5030 3360 5120 3360 { lab=b1}
N 5030 3380 5120 3380 { lab=nb0}
N 5030 3470 5120 3470 { lab=nb4}
N 5030 3490 5120 3490 { lab=b3}
N 5030 3510 5120 3510 { lab=b2}
N 5030 3530 5120 3530 { lab=nb1}
N 5030 3550 5120 3550 { lab=b0}
N 5030 3610 5120 3610 { lab=nb4}
N 5030 3630 5120 3630 { lab=b3}
N 5030 3650 5120 3650 { lab=b2}
N 5030 3670 5120 3670 { lab=nb1}
N 5030 3690 5120 3690 { lab=nb0}
N 5030 3770 5120 3770 { lab=nb4}
N 5030 3790 5120 3790 { lab=b3}
N 5030 3810 5120 3810 { lab=nb2}
N 5030 3830 5120 3830 { lab=b1}
N 5030 3850 5120 3850 { lab=b0}
N 5030 3950 5130 3950 { lab=nb4}
N 5030 3970 5130 3970 { lab=b3}
N 5030 3990 5130 3990 { lab=nb2}
N 5030 4010 5130 4010 { lab=b1}
N 5030 4030 5130 4030 { lab=nb0}
N 5020 4130 5120 4130 { lab=nb4}
N 5020 4150 5120 4150 { lab=b3}
N 5020 4170 5120 4170 { lab=nb2}
N 5020 4190 5120 4190 { lab=nb1}
N 5030 4210 5120 4210 { lab=b0}
N 5030 4310 5120 4310 { lab=nb4}
N 5030 4330 5120 4330 { lab=b3}
N 5030 4350 5120 4350 { lab=nb2}
N 5030 4370 5120 4370 { lab=nb1}
N 5030 4390 5120 4390 { lab=nb0}
N 5030 4470 5120 4470 { lab=nb4}
N 5030 4490 5120 4490 { lab=nb3}
N 5030 4510 5120 4510 { lab=b2}
N 5030 4530 5120 4530 { lab=b1}
N 5030 4550 5120 4550 { lab=b0}
N 5030 4630 5120 4630 { lab=nb4}
N 5030 4650 5120 4650 { lab=nb3}
N 5030 4670 5120 4670 { lab=b2}
N 5030 4690 5120 4690 { lab=b1}
N 5030 4710 5120 4710 { lab=nb0}
N 5030 4770 5120 4770 { lab=nb4}
N 5030 4790 5120 4790 { lab=nb3}
N 5030 4810 5120 4810 { lab=b2}
N 5030 4830 5120 4830 { lab=nb1}
N 5030 4850 5120 4850 { lab=b0}
N 5030 4910 5120 4910 { lab=nb4}
N 5030 4930 5120 4930 { lab=nb3}
N 5030 4950 5120 4950 { lab=b2}
N 5030 4970 5120 4970 { lab=nb1}
N 5030 4990 5120 4990 { lab=nb0}
N 5030 5070 5120 5070 { lab=nb4}
N 5030 5090 5120 5090 { lab=nb3}
N 5030 5110 5120 5110 { lab=nb2}
N 5030 5130 5120 5130 { lab=b1}
N 5030 5150 5120 5150 { lab=b0}
N 5030 5220 5120 5220 { lab=nb4}
N 5030 5240 5120 5240 { lab=nb3}
N 5030 5260 5120 5260 { lab=nb2}
N 5030 5280 5120 5280 { lab=b1}
N 5030 5300 5120 5300 { lab=nb0}
N 5030 5380 5130 5380 { lab=nb4}
N 5030 5400 5130 5400 { lab=nb3}
N 5030 5420 5130 5420 { lab=nb2}
N 5030 5440 5130 5440 { lab=nb1}
N 5040 5460 5130 5460 { lab=b0}
N 5030 5460 5040 5460 { lab=b0}
N 5030 5540 5140 5540 { lab=nb4}
N 5030 5560 5140 5560 { lab=nb3}
N 5030 5580 5140 5580 { lab=nb2}
N 5030 5600 5140 5600 { lab=nb1}
N 5030 5620 5140 5620 { lab=nb0}
N 5560 230 5560 250 { lab=MSB1_out}
N 5490 5560 5510 5560 { lab=MSB2_out}
N 5490 5560 5490 5660 { lab=MSB2_out}
N 5470 5660 5490 5660 { lab=MSB2_out}
N 5440 5580 5510 5580 { lab=Out}
N 5440 5560 5490 5560 { lab=MSB2_out}
N 5470 3140 5540 3140 { lab=#net134}
N 5610 3160 5680 3160 { lab=Out}
N 5490 230 5560 230 { lab=MSB1_out}
N 5430 310 5500 310 { lab=#net150}
N 5430 330 5500 330 { lab=Out}
N 5440 490 5510 490 { lab=#net149}
N 5440 510 5510 510 { lab=Out}
N 5440 660 5510 660 { lab=#net148}
N 5440 680 5510 680 { lab=Out}
N 5430 800 5510 800 { lab=#net147}
N 5430 820 5510 820 { lab=Out}
N 5440 960 5510 960 { lab=#net146}
N 5440 980 5510 980 { lab=Out}
N 5450 1140 5520 1140 { lab=#net145}
N 5450 1160 5520 1160 { lab=Out}
N 5420 1320 5490 1320 { lab=#net144}
N 5420 1340 5490 1340 { lab=Out}
N 5420 1500 5500 1500 { lab=#net143}
N 5420 1520 5500 1520 { lab=Out}
N 5420 1710 5490 1710 { lab=#net142}
N 5420 1730 5490 1730 { lab=Out}
N 5430 1890 5500 1890 { lab=#net141}
N 5430 1910 5500 1910 { lab=Out}
N 5430 2060 5500 2060 { lab=#net140}
N 5430 2080 5500 2080 { lab=Out}
N 5430 2200 5500 2200 { lab=#net139}
N 5430 2220 5500 2220 { lab=Out}
N 5430 2360 5500 2360 { lab=#net138}
N 5430 2380 5500 2380 { lab=Out}
N 5440 2540 5510 2540 { lab=#net137}
N 5440 2560 5510 2560 { lab=Out}
N 5420 2720 5500 2720 { lab=#net136}
N 5420 2740 5500 2740 { lab=Out}
N 5430 2900 5500 2900 { lab=#net135}
N 5430 2920 5500 2920 { lab=Out}
N 5680 3030 5970 3030 { lab=Out}
N 5420 3320 5490 3320 { lab=#net133}
N 5420 3340 5490 3340 { lab=Out}
N 5420 3490 5490 3490 { lab=#net132}
N 5420 3510 5490 3510 { lab=Out}
N 5420 3630 5490 3630 { lab=#net131}
N 5420 3650 5490 3650 { lab=Out}
N 5420 3790 5490 3790 { lab=#net130}
N 5420 3810 5490 3810 { lab=Out}
N 5430 3970 5500 3970 { lab=#net129}
N 5430 3990 5500 3990 { lab=Out}
N 5420 4150 5490 4150 { lab=#net128}
N 5420 4170 5490 4170 { lab=Out}
N 5420 4330 5490 4330 { lab=#net127}
N 5420 4350 5490 4350 { lab=Out}
N 5420 4490 5490 4490 { lab=#net151}
N 5420 4510 5490 4510 { lab=Out}
N 5420 4650 5490 4650 { lab=#net152}
N 5420 4670 5490 4670 { lab=Out}
N 5420 4790 5490 4790 { lab=#net153}
N 5420 4810 5490 4810 { lab=Out}
N 5420 4930 5490 4930 { lab=#net154}
N 5420 4950 5490 4950 { lab=Out}
N 5420 5090 5490 5090 { lab=#net155}
N 5420 5110 5490 5110 { lab=Out}
N 5420 5240 5490 5240 { lab=#net156}
N 5420 5260 5490 5260 { lab=Out}
N 5430 5400 5500 5400 { lab=#net157}
N 5430 5420 5500 5420 { lab=Out}
N 5440 5600 5480 5600 { lab=GND}
N 5480 350 5480 5600 { lab=GND}
N 5430 350 5480 350 { lab=GND}
N 5480 5600 5480 5640 { lab=GND}
N 5430 5440 5480 5440 { lab=GND}
N 5420 5280 5480 5280 { lab=GND}
N 5420 5130 5480 5130 { lab=GND}
N 5420 4970 5480 4970 { lab=GND}
N 5420 4830 5480 4830 { lab=GND}
N 5420 4690 5480 4690 { lab=GND}
N 5420 4530 5480 4530 { lab=GND}
N 5420 4370 5480 4370 { lab=GND}
N 5420 4190 5480 4190 { lab=GND}
N 5430 4010 5480 4010 { lab=GND}
N 5420 3830 5480 3830 { lab=GND}
N 5420 3670 5480 3670 { lab=GND}
N 5420 3530 5480 3530 { lab=GND}
N 5420 3360 5480 3360 { lab=GND}
N 5410 3180 5480 3180 { lab=GND}
N 5430 2940 5480 2940 { lab=GND}
N 5420 2760 5480 2760 { lab=GND}
N 5440 2580 5480 2580 { lab=GND}
N 5430 2400 5480 2400 { lab=GND}
N 5430 2100 5480 2100 { lab=GND}
N 5430 2240 5480 2240 { lab=GND}
N 5420 1750 5480 1750 { lab=GND}
N 5430 1930 5480 1930 { lab=GND}
N 5420 1360 5480 1360 { lab=GND}
N 5420 1540 5480 1540 { lab=GND}
N 5440 1000 5480 1000 { lab=GND}
N 5450 1180 5480 1180 { lab=GND}
N 5440 700 5480 700 { lab=GND}
N 5430 840 5480 840 { lab=GND}
N 5440 530 5480 530 { lab=GND}
N 5440 5540 5460 5540 { lab=VDD}
N 5460 240 5460 5540 { lab=VDD}
N 5430 290 5460 290 { lab=VDD}
N 5440 470 5460 470 { lab=VDD}
N 5440 640 5460 640 { lab=VDD}
N 5430 780 5460 780 { lab=VDD}
N 5440 940 5460 940 { lab=VDD}
N 5450 1120 5460 1120 { lab=VDD}
N 5420 1300 5460 1300 { lab=VDD}
N 5420 1480 5460 1480 { lab=VDD}
N 5430 1870 5460 1870 { lab=VDD}
N 5420 1690 5460 1690 { lab=VDD}
N 5430 2040 5460 2040 { lab=VDD}
N 5430 2180 5460 2180 { lab=VDD}
N 5430 2340 5460 2340 { lab=VDD}
N 5440 2520 5460 2520 { lab=VDD}
N 5420 2700 5460 2700 { lab=VDD}
N 5430 2880 5460 2880 { lab=VDD}
N 5410 3120 5460 3120 { lab=VDD}
N 5420 3300 5460 3300 { lab=VDD}
N 5420 3470 5460 3470 { lab=VDD}
N 5420 3610 5460 3610 { lab=VDD}
N 5420 3770 5460 3770 { lab=VDD}
N 5430 3950 5460 3950 { lab=VDD}
N 5420 4130 5460 4130 { lab=VDD}
N 5420 4310 5460 4310 { lab=VDD}
N 5420 4470 5460 4470 { lab=VDD}
N 5420 4630 5460 4630 { lab=VDD}
N 5420 4770 5460 4770 { lab=VDD}
N 5420 4910 5460 4910 { lab=VDD}
N 5420 5070 5460 5070 { lab=VDD}
N 5420 5220 5460 5220 { lab=VDD}
N 5430 5380 5460 5380 { lab=VDD}
N 2560 4460 2640 4460 { lab=VDD}
N 2560 4520 2720 4520 { lab=GND}
C {/home/shalini1234/Project/5bit_AND.sym} 2380 430 0 0 {name=x1}
C {/home/shalini1234/Project/5bit_AND.sym} 2390 760 0 0 {name=x3}
C {/home/shalini1234/Project/5bit_AND.sym} 2390 900 0 0 {name=x4}
C {/home/shalini1234/Project/5bit_AND.sym} 2390 1040 0 0 {name=x5}
C {/home/shalini1234/Project/5bit_AND.sym} 2400 1170 0 0 {name=x6}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 1300 0 0 {name=x7}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 1430 0 0 {name=x8}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 1570 0 0 {name=x9}
C {/home/shalini1234/Project/5bit_AND.sym} 2380 600 0 0 {name=x2}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 1710 0 0 {name=x10}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 1840 0 0 {name=x11}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 2000 0 0 {name=x12}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 2150 0 0 {name=x13}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 2300 0 0 {name=x14}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 2470 0 0 {name=x15}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 2640 0 0 {name=x16}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 2780 0 0 {name=x17}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 2920 0 0 {name=x18}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 3060 0 0 {name=x19}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 3200 0 0 {name=x20}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 3340 0 0 {name=x21}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 3480 0 0 {name=x22}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 3620 0 0 {name=x23}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 3770 0 0 {name=x24}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 3930 0 0 {name=x25}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 4080 0 0 {name=x26}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 4220 0 0 {name=x27}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 4360 0 0 {name=x28}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 4500 0 0 {name=x29}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 4630 0 0 {name=x30}
C {/home/shalini1234/Project/5bit_AND.sym} 2420 4750 0 0 {name=x31}
C {/home/shalini1234/Project/5bit_AND.sym} 2410 4880 0 0 {name=x32}
C {/home/shalini1234/Project/Switch.sym} 3060 400 0 0 {name=x33}
C {/home/shalini1234/Project/Switch.sym} 3780 400 0 0 {name=x34}
C {/home/shalini1234/Project/Switch.sym} 3050 570 0 0 {name=x35}
C {/home/shalini1234/Project/Switch.sym} 3770 570 0 0 {name=x36}
C {/home/shalini1234/Project/Switch.sym} 3050 730 0 0 {name=x37}
C {/home/shalini1234/Project/Switch.sym} 3780 730 0 0 {name=x38}
C {/home/shalini1234/Project/Switch.sym} 3060 870 0 0 {name=x39}
C {/home/shalini1234/Project/Switch.sym} 3780 870 0 0 {name=x40}
C {/home/shalini1234/Project/Switch.sym} 3060 1010 0 0 {name=x41}
C {/home/shalini1234/Project/Switch.sym} 3780 1010 0 0 {name=x42}
C {/home/shalini1234/Project/Switch.sym} 3060 1140 0 0 {name=x43}
C {/home/shalini1234/Project/Switch.sym} 3780 1140 0 0 {name=x44}
C {/home/shalini1234/Project/Switch.sym} 3060 1270 0 0 {name=x45}
C {/home/shalini1234/Project/Switch.sym} 3780 1270 0 0 {name=x46}
C {/home/shalini1234/Project/Switch.sym} 3060 1400 0 0 {name=x47}
C {/home/shalini1234/Project/Switch.sym} 3790 1400 0 0 {name=x48}
C {/home/shalini1234/Project/Switch.sym} 3060 1540 0 0 {name=x49}
C {/home/shalini1234/Project/Switch.sym} 3790 1540 0 0 {name=x50}
C {/home/shalini1234/Project/Switch.sym} 3050 1680 0 0 {name=x51}
C {/home/shalini1234/Project/Switch.sym} 3800 1680 0 0 {name=x52}
C {/home/shalini1234/Project/Switch.sym} 3060 1810 0 0 {name=x53}
C {/home/shalini1234/Project/Switch.sym} 3790 1810 0 0 {name=x54}
C {/home/shalini1234/Project/Switch.sym} 3060 1970 0 0 {name=x55}
C {/home/shalini1234/Project/Switch.sym} 3800 1970 0 0 {name=x56}
C {/home/shalini1234/Project/Switch.sym} 3060 2120 0 0 {name=x57}
C {/home/shalini1234/Project/Switch.sym} 3800 2120 0 0 {name=x58}
C {/home/shalini1234/Project/Switch.sym} 3060 2270 0 0 {name=x59}
C {/home/shalini1234/Project/Switch.sym} 3800 2260 0 0 {name=x60}
C {/home/shalini1234/Project/Switch.sym} 3060 2440 0 0 {name=x61}
C {/home/shalini1234/Project/Switch.sym} 3810 2440 0 0 {name=x62}
C {/home/shalini1234/Project/Switch.sym} 3060 2610 0 0 {name=x63}
C {/home/shalini1234/Project/Switch.sym} 3810 2610 0 0 {name=x64}
C {/home/shalini1234/Project/Switch.sym} 3060 2750 0 0 {name=x65}
C {/home/shalini1234/Project/Switch.sym} 3810 2750 0 0 {name=x66}
C {/home/shalini1234/Project/Switch.sym} 3070 2890 0 0 {name=x67}
C {/home/shalini1234/Project/Switch.sym} 3810 2890 0 0 {name=x68}
C {/home/shalini1234/Project/Switch.sym} 3060 3030 0 0 {name=x69}
C {/home/shalini1234/Project/Switch.sym} 3840 3030 0 0 {name=x70}
C {/home/shalini1234/Project/Switch.sym} 3060 3170 0 0 {name=x71}
C {/home/shalini1234/Project/Switch.sym} 3820 3170 0 0 {name=x72}
C {/home/shalini1234/Project/Switch.sym} 3060 3310 0 0 {name=x73}
C {/home/shalini1234/Project/Switch.sym} 3820 3310 0 0 {name=x74}
C {/home/shalini1234/Project/Switch.sym} 3060 3450 0 0 {name=x75}
C {/home/shalini1234/Project/Switch.sym} 3820 3450 0 0 {name=x76}
C {/home/shalini1234/Project/Switch.sym} 3060 3590 0 0 {name=x77}
C {/home/shalini1234/Project/Switch.sym} 3830 3590 0 0 {name=x78}
C {/home/shalini1234/Project/Switch.sym} 3060 3740 0 0 {name=x79}
C {/home/shalini1234/Project/Switch.sym} 3830 3740 0 0 {name=x80}
C {/home/shalini1234/Project/Switch.sym} 3070 3900 0 0 {name=x81}
C {/home/shalini1234/Project/Switch.sym} 3830 3900 0 0 {name=x82}
C {/home/shalini1234/Project/Switch.sym} 3080 4050 0 0 {name=x83}
C {/home/shalini1234/Project/Switch.sym} 3830 4050 0 0 {name=x84}
C {/home/shalini1234/Project/Switch.sym} 3080 4190 0 0 {name=x85}
C {/home/shalini1234/Project/Switch.sym} 3830 4190 0 0 {name=x86}
C {/home/shalini1234/Project/Switch.sym} 3080 4330 0 0 {name=x87}
C {/home/shalini1234/Project/Switch.sym} 3830 4310 0 0 {name=x88}
C {/home/shalini1234/Project/Switch.sym} 3080 4470 0 0 {name=x89}
C {/home/shalini1234/Project/Switch.sym} 3830 4470 0 0 {name=x90}
C {/home/shalini1234/Project/Switch.sym} 3080 4600 0 0 {name=x91}
C {/home/shalini1234/Project/Switch.sym} 3830 4600 0 0 {name=x92}
C {/home/shalini1234/Project/Switch.sym} 3080 4720 0 0 {name=x93}
C {/home/shalini1234/Project/Switch.sym} 3830 4720 0 0 {name=x94}
C {/home/shalini1234/Project/Switch.sym} 3080 4850 0 0 {name=x95}
C {/home/shalini1234/Project/Switch.sym} 3830 4850 0 0 {name=x96}
C {res.sym} 3360 540 0 0 {name=R1
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 700 0 0 {name=R2
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 840 0 0 {name=R3
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 980 0 0 {name=R4
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 1110 0 0 {name=R5
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 1240 0 0 {name=R6
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 1370 0 0 {name=R7
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 1510 0 0 {name=R8
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 1650 0 0 {name=R9
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 1780 0 0 {name=R10
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 1940 0 0 {name=R11
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 2090 0 0 {name=R12
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 2230 0 0 {name=R13
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 2410 0 0 {name=R14
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 2570 0 0 {name=R15
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 2720 0 0 {name=R16
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 2860 0 0 {name=R17
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 3000 0 0 {name=R18
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 3140 0 0 {name=R19
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 3280 0 0 {name=R20
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 3420 0 0 {name=R21
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 3560 0 0 {name=R22
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 3710 0 0 {name=R23
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 3870 0 0 {name=R24
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 4020 0 0 {name=R25
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 4150 0 0 {name=R26
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 4300 0 0 {name=R27
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 4430 0 0 {name=R28
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 4570 0 0 {name=R29
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 4690 0 0 {name=R30
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 3360 4820 0 0 {name=R31
value=1k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 3450 4900 0 0 {name=l2 sig_type=std_logic lab=MSB1_out}
C {lab_pin.sym} 3360 340 0 0 {name=l4 sig_type=std_logic lab=pVref}
C {lab_pin.sym} 4160 4900 0 0 {name=l3 sig_type=std_logic lab=MSB2_out}
C {res.sym} 4050 480 0 0 {name=R32
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 650 0 0 {name=R33
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 800 0 0 {name=R34
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 940 0 0 {name=R35
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 1080 0 0 {name=R36
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 1220 0 0 {name=R37
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 1350 0 0 {name=R38
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 1480 0 0 {name=R39
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 1620 0 0 {name=R40
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 1760 0 0 {name=R41
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 1890 0 0 {name=R42
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 2050 0 0 {name=R43
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 2200 0 0 {name=R44
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 2340 0 0 {name=R45
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 2530 0 0 {name=R46
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 2690 0 0 {name=R47
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 2830 0 0 {name=R48
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 2960 0 0 {name=R49
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 3110 0 0 {name=R50
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 3250 0 0 {name=R51
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 3390 0 0 {name=R52
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 3530 0 0 {name=R53
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 3670 0 0 {name=R54
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 3820 0 0 {name=R55
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 3980 0 0 {name=R56
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 4130 0 0 {name=R57
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 4260 0 0 {name=R58
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 4400 0 0 {name=R59
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 4540 0 0 {name=R60
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 4670 0 0 {name=R61
value=1k
footprint=1206
device=resistor
m=1}
C {res.sym} 4050 4790 0 0 {name=R62
value=1k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 4050 4890 0 0 {name=l5 sig_type=std_logic lab=nVref}
C {lab_pin.sym} 2130 390 0 0 {name=l6 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2130 410 0 0 {name=l7 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2130 430 0 0 {name=l8 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2130 450 0 0 {name=l9 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2130 470 0 0 {name=l10 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2120 560 0 0 {name=l11 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2120 580 0 0 {name=l12 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2120 600 0 0 {name=l13 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2120 620 0 0 {name=l14 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2120 640 0 0 {name=l15 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2120 720 0 0 {name=l17 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2120 740 0 0 {name=l18 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2120 760 0 0 {name=l19 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2120 780 0 0 {name=l20 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2120 800 0 0 {name=l21 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2120 860 0 0 {name=l22 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2120 880 0 0 {name=l23 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2120 900 0 0 {name=l24 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2120 920 0 0 {name=l25 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2120 940 0 0 {name=l26 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2130 1000 0 0 {name=l27 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2130 1020 0 0 {name=l28 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2130 1040 0 0 {name=l29 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2130 1060 0 0 {name=l30 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2130 1080 0 0 {name=l31 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2130 1130 0 0 {name=l32 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2130 1150 0 0 {name=l33 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2130 1170 0 0 {name=l34 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2130 1190 0 0 {name=l35 sig_type=std_logic lab=b6
}
C {lab_pin.sym} 2130 1210 0 0 {name=l36 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2140 1260 0 0 {name=l37 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2140 1280 0 0 {name=l38 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2140 1300 0 0 {name=l39 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2140 1320 0 0 {name=l40 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2140 1340 0 0 {name=l41 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2140 1390 0 0 {name=l42 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2140 1410 0 0 {name=l43 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2140 1430 0 0 {name=l44 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2140 1450 0 0 {name=l45 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2140 1470 0 0 {name=l46 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2140 1530 0 0 {name=l47 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2140 1550 0 0 {name=l48 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2140 1570 0 0 {name=l49 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2140 1590 0 0 {name=l50 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2140 1610 0 0 {name=l51 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 1670 0 0 {name=l52 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2150 1690 0 0 {name=l53 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 1710 0 0 {name=l54 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2150 1730 0 0 {name=l55 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2150 1750 0 0 {name=l56 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2150 1800 0 0 {name=l57 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2150 1820 0 0 {name=l58 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 1840 0 0 {name=l59 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2150 1860 0 0 {name=l60 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 1880 0 0 {name=l61 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 1960 0 0 {name=l62 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2150 1980 0 0 {name=l63 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 2000 0 0 {name=l64 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2150 2020 0 0 {name=l65 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 2040 0 0 {name=l66 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2150 2110 0 0 {name=l67 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2150 2130 0 0 {name=l68 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 2150 0 0 {name=l69 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 2170 0 0 {name=l70 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2150 2190 0 0 {name=l71 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 2260 0 0 {name=l72 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2150 2280 0 0 {name=l73 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 2300 0 0 {name=l74 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 2320 0 0 {name=l75 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2150 2340 0 0 {name=l76 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2150 2430 0 0 {name=l77 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2150 2450 0 0 {name=l78 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 2470 0 0 {name=l79 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 2490 0 0 {name=l80 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 2510 0 0 {name=l81 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 2600 0 0 {name=l82 sig_type=std_logic lab=b9}
C {lab_pin.sym} 2150 2620 0 0 {name=l83 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 2640 0 0 {name=l84 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 2660 0 0 {name=l85 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 2680 0 0 {name=l86 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2150 2740 0 0 {name=l87 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 2760 0 0 {name=l88 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2150 2780 0 0 {name=l89 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2150 2800 0 0 {name=l90 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2150 2820 0 0 {name=l91 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 2880 0 0 {name=l92 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 2900 0 0 {name=l93 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2150 2920 0 0 {name=l94 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2150 2940 0 0 {name=l95 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2150 2960 0 0 {name=l96 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2150 3020 0 0 {name=l97 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 3040 0 0 {name=l98 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2150 3060 0 0 {name=l99 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2150 3080 0 0 {name=l100 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 3100 0 0 {name=l101 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 3160 0 0 {name=l102 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 3180 0 0 {name=l103 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2150 3200 0 0 {name=l104 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2150 3220 0 0 {name=l105 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 3240 0 0 {name=l106 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2150 3300 0 0 {name=l107 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 3320 0 0 {name=l108 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2150 3340 0 0 {name=l109 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 3360 0 0 {name=l110 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2150 3380 0 0 {name=l111 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 3440 0 0 {name=l112 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 3460 0 0 {name=l113 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2150 3480 0 0 {name=l114 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 3500 0 0 {name=l115 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2150 3520 0 0 {name=l116 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2150 3580 0 0 {name=l117 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 3600 0 0 {name=l118 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2150 3620 0 0 {name=l119 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 3640 0 0 {name=l120 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 3660 0 0 {name=l121 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 3730 0 0 {name=l122 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 3750 0 0 {name=l123 sig_type=std_logic lab=b8}
C {lab_pin.sym} 2150 3770 0 0 {name=l124 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 3790 0 0 {name=l125 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 3810 0 0 {name=l126 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2150 3890 0 0 {name=l127 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 3910 0 0 {name=l128 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 3930 0 0 {name=l129 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2150 3950 0 0 {name=l130 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2150 3970 0 0 {name=l131 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 4040 0 0 {name=l132 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 4060 0 0 {name=l133 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 4080 0 0 {name=l134 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2150 4100 0 0 {name=l135 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2150 4120 0 0 {name=l136 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2150 4180 0 0 {name=l137 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 4200 0 0 {name=l138 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 4220 0 0 {name=l139 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2150 4240 0 0 {name=l140 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 4260 0 0 {name=l141 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 4320 0 0 {name=l142 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 4340 0 0 {name=l143 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 4360 0 0 {name=l144 sig_type=std_logic lab=b7}
C {lab_pin.sym} 2150 4380 0 0 {name=l145 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 4400 0 0 {name=l146 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2150 4460 0 0 {name=l147 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 4480 0 0 {name=l148 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 4500 0 0 {name=l149 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 4520 0 0 {name=l150 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2150 4540 0 0 {name=l151 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 4590 0 0 {name=l152 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 4610 0 0 {name=l153 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 4630 0 0 {name=l154 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 4650 0 0 {name=l155 sig_type=std_logic lab=b6}
C {lab_pin.sym} 2150 4670 0 0 {name=l156 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 2150 4710 0 0 {name=l157 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 4730 0 0 {name=l158 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 4750 0 0 {name=l159 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 4770 0 0 {name=l160 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 4790 0 0 {name=l161 sig_type=std_logic lab=b5}
C {lab_pin.sym} 2150 4840 0 0 {name=l162 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 2150 4860 0 0 {name=l163 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 2150 4880 0 0 {name=l164 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 2150 4900 0 0 {name=l165 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 2150 4920 0 0 {name=l166 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 3780 4960 0 0 {name=l1 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2640 340 0 0 {name=l16 sig_type=std_logic lab=VDD}
C {vsource.sym} 330 250 0 0 {name=V_Bit9 value=1.8}
C {vsource.sym} 620 270 0 0 {name=V_Bit8 value=3}
C {vsource.sym} 870 260 0 0 {name=V_Bit7 value=1.8}
C {vsource.sym} 1140 250 0 0 {name=V_Bit6 value=1.8}
C {vsource.sym} 1390 250 0 0 {name=V_Bit5 value=1.8}
C {vsource.sym} 310 530 0 0 {name=V_Bit4 value=1.8}
C {vsource.sym} 610 540 0 0 {name=V_Bit3 value=1.8}
C {vsource.sym} 870 530 0 0 {name=V_Bit2 value=1.8}
C {vsource.sym} 1140 520 0 0 {name=V_Bit1 value=1.8}
C {vsource.sym} 1400 540 0 0 {name=V_Bit0 value=1.8}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 420 310 0 0 {name=M1
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 420 180 0 0 {name=M2
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 700 310 0 0 {name=M3
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 700 180 0 0 {name=M4
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 960 310 0 0 {name=M5
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 960 180 0 0 {name=M6
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 1220 310 0 0 {name=M7
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 1220 180 0 0 {name=M8
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 1470 310 0 0 {name=M9
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 1470 180 0 0 {name=M10
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 410 590 0 0 {name=M11
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 410 460 0 0 {name=M12
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 700 590 0 0 {name=M13
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 700 460 0 0 {name=M14
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 960 590 0 0 {name=M15
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 960 460 0 0 {name=M16
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 1230 590 0 0 {name=M17
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 1230 460 0 0 {name=M18
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/nfet_01v8.sym} 1480 590 0 0 {name=M19
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/usr/local/share/xschem_sky130/sky130_fd_pr/pfet_01v8.sym} 1480 460 0 0 {name=M20
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 490 240 2 0 {name=l330 sig_type=std_logic lab=nb9}
C {lab_pin.sym} 340 210 0 0 {name=l333 sig_type=std_logic lab=b9}
C {lab_pin.sym} 1570 620 2 0 {name=l334 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1560 340 2 0 {name=l338 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1310 340 2 0 {name=l339 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1040 340 2 0 {name=l340 sig_type=std_logic lab=GND}
C {lab_pin.sym} 790 340 2 0 {name=l341 sig_type=std_logic lab=GND}
C {lab_pin.sym} 510 340 2 0 {name=l342 sig_type=std_logic lab=GND}
C {lab_pin.sym} 500 620 2 0 {name=l343 sig_type=std_logic lab=GND}
C {lab_pin.sym} 790 620 2 0 {name=l344 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1050 620 2 0 {name=l345 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1320 620 2 0 {name=l346 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1500 410 0 0 {name=l349 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1250 400 0 0 {name=l350 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 980 400 0 0 {name=l351 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 720 410 0 0 {name=l352 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 430 410 0 0 {name=l353 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 440 130 0 0 {name=l354 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 720 130 0 0 {name=l355 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 980 130 0 0 {name=l356 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1240 130 0 0 {name=l357 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1490 130 0 0 {name=l358 sig_type=std_logic lab=VDD}
C {vsource.sym} 1860 170 0 0 {name=pVref value=3.3}
C {vsource.sym} 2020 180 0 0 {name=nVref value=3.3}
C {gnd.sym} 1700 170 0 0 {name=l329 lab=GND}
C {lab_pin.sym} 1860 120 0 0 {name=l331 sig_type=std_logic lab=pVref}
C {lab_pin.sym} 2020 240 0 0 {name=l332 sig_type=std_logic lab=nVref}
C {lab_pin.sym} 1700 140 0 0 {name=l335 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1860 220 0 0 {name=l336 sig_type=std_logic lab=GND}
C {lab_pin.sym} 2020 110 0 0 {name=l337 sig_type=std_logic lab=GND}
C {vdd.sym} 1750 60 0 0 {name=l347 lab=VDD}
C {lab_pin.sym} 1750 70 0 0 {name=l348 sig_type=std_logic lab=VDD}
C {res.sym} 5560 280 0 0 {name=R63
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5560 460 0 0 {name=R64
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5560 630 0 0 {name=R65
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5560 770 0 0 {name=R66
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5560 930 0 0 {name=R67
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5560 1110 0 0 {name=R68
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5560 1280 0 0 {name=R69
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 1470 0 0 {name=R70
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 1680 0 0 {name=R71
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 1850 0 0 {name=R72
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 2030 0 0 {name=R73
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 2170 0 0 {name=R74
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 2330 0 0 {name=R75
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 2510 0 0 {name=R76
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 2690 0 0 {name=R77
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 2870 0 0 {name=R78
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 3110 0 0 {name=R79
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 3290 0 0 {name=R80
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 3450 0 0 {name=R81
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 3600 0 0 {name=R82
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 3760 0 0 {name=R83
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 3940 0 0 {name=R84
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 4120 0 0 {name=R85
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 4300 0 0 {name=R86
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 4440 0 0 {name=R87
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 4600 0 0 {name=R88
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 4740 0 0 {name=R89
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 4900 0 0 {name=R90
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 5060 0 0 {name=R91
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 5210 0 0 {name=R92
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 5370 0 0 {name=R93
value=31.25
footprint=1206
device=resistor
m=1}
C {res.sym} 5540 5530 0 0 {name=R94
value=31.25
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 5140 5660 0 0 {name=l167 sig_type=std_logic lab=MSB2_out}
C {lab_pin.sym} 5260 230 0 0 {name=l168 sig_type=std_logic lab=MSB1_out}
C {lab_pin.sym} 5030 5620 0 0 {name=l169 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 5600 0 0 {name=l170 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 5580 0 0 {name=l171 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 5560 0 0 {name=l172 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 5540 0 0 {name=l173 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 5460 0 0 {name=l174 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 5440 0 0 {name=l175 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 5420 0 0 {name=l176 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 5400 0 0 {name=l177 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 5380 0 0 {name=l178 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 5300 0 0 {name=l179 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 5280 0 0 {name=l180 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 5260 0 0 {name=l181 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 5240 0 0 {name=l182 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 5220 0 0 {name=l183 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 5150 0 0 {name=l184 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 5130 0 0 {name=l185 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 5110 0 0 {name=l186 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 5090 0 0 {name=l187 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 5070 0 0 {name=l188 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 4990 0 0 {name=l189 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 4970 0 0 {name=l190 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 4950 0 0 {name=l191 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 4930 0 0 {name=l192 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 4910 0 0 {name=l193 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 4850 0 0 {name=l194 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 4830 0 0 {name=l195 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 4810 0 0 {name=l196 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 4790 0 0 {name=l197 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 4770 0 0 {name=l198 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 4710 0 0 {name=l199 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 4690 0 0 {name=l200 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 4670 0 0 {name=l201 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 4650 0 0 {name=l202 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 4630 0 0 {name=l203 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 4550 0 0 {name=l204 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 4530 0 0 {name=l205 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 4510 0 0 {name=l206 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 4490 0 0 {name=l207 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 4470 0 0 {name=l208 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 4390 0 0 {name=l209 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 4370 0 0 {name=l210 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 4350 0 0 {name=l211 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 4330 0 0 {name=l212 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 4310 0 0 {name=l213 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 4210 0 0 {name=l214 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5020 4190 0 0 {name=l215 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5020 4170 0 0 {name=l216 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5020 4150 0 0 {name=l217 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5020 4130 0 0 {name=l218 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 4030 0 0 {name=l219 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 4010 0 0 {name=l220 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 3990 0 0 {name=l221 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 3970 0 0 {name=l222 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 3950 0 0 {name=l223 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 3850 0 0 {name=l224 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 3830 0 0 {name=l225 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 3810 0 0 {name=l226 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 3790 0 0 {name=l227 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 3770 0 0 {name=l228 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 3470 0 0 {name=l229 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 3490 0 0 {name=l230 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 3510 0 0 {name=l231 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 3530 0 0 {name=l232 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 3550 0 0 {name=l233 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 3610 0 0 {name=l234 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 3630 0 0 {name=l235 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 3650 0 0 {name=l236 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 3670 0 0 {name=l237 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 3690 0 0 {name=l238 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 290 0 0 {name=l239 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 310 0 0 {name=l240 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 330 0 0 {name=l241 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 350 0 0 {name=l242 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 370 0 0 {name=l243 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 470 0 0 {name=l244 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 490 0 0 {name=l245 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 510 0 0 {name=l246 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 530 0 0 {name=l247 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 550 0 0 {name=l248 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 640 0 0 {name=l249 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 660 0 0 {name=l250 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 680 0 0 {name=l251 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 700 0 0 {name=l252 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 720 0 0 {name=l253 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 780 0 0 {name=l254 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 800 0 0 {name=l255 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 820 0 0 {name=l256 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 840 0 0 {name=l257 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 860 0 0 {name=l258 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 940 0 0 {name=l259 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 960 0 0 {name=l260 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 980 0 0 {name=l261 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 1000 0 0 {name=l262 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 1020 0 0 {name=l263 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 1120 0 0 {name=l264 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 1140 0 0 {name=l265 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 1160 0 0 {name=l266 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 1180 0 0 {name=l267 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 1200 0 0 {name=l268 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 1300 0 0 {name=l269 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 1320 0 0 {name=l270 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 1340 0 0 {name=l271 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 1360 0 0 {name=l272 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 1380 0 0 {name=l273 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 1480 0 0 {name=l274 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 1500 0 0 {name=l275 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 1520 0 0 {name=l276 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 1540 0 0 {name=l277 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 1560 0 0 {name=l278 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 1690 0 0 {name=l279 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 1710 0 0 {name=l280 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 1730 0 0 {name=l281 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 1750 0 0 {name=l282 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 1770 0 0 {name=l283 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 1870 0 0 {name=l284 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 1890 0 0 {name=l285 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 1910 0 0 {name=l286 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 1930 0 0 {name=l287 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 1950 0 0 {name=l288 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 2040 0 0 {name=l289 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 2060 0 0 {name=l290 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 2080 0 0 {name=l291 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 2100 0 0 {name=l292 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 2120 0 0 {name=l293 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 2180 0 0 {name=l294 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 2200 0 0 {name=l295 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 2220 0 0 {name=l296 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 2240 0 0 {name=l297 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 2260 0 0 {name=l298 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 2340 0 0 {name=l299 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 2360 0 0 {name=l300 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 2380 0 0 {name=l301 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 2400 0 0 {name=l302 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 2420 0 0 {name=l303 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 2520 0 0 {name=l304 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 2540 0 0 {name=l305 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 2560 0 0 {name=l306 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 2580 0 0 {name=l307 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 2600 0 0 {name=l308 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 2700 0 0 {name=l309 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 2720 0 0 {name=l310 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 2740 0 0 {name=l311 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 2760 0 0 {name=l312 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 2780 0 0 {name=l313 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 2880 0 0 {name=l314 sig_type=std_logic lab=b4}
C {lab_pin.sym} 5030 2900 0 0 {name=l315 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 5030 2920 0 0 {name=l316 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 5030 2940 0 0 {name=l317 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 5030 2960 0 0 {name=l318 sig_type=std_logic lab=nb0}
C {lab_pin.sym} 5030 3120 0 0 {name=l319 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 3140 0 0 {name=l320 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 3160 0 0 {name=l321 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 3180 0 0 {name=l322 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 3200 0 0 {name=l323 sig_type=std_logic lab=b0}
C {lab_pin.sym} 5030 3300 0 0 {name=l324 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 5030 3320 0 0 {name=l325 sig_type=std_logic lab=b3}
C {lab_pin.sym} 5030 3340 0 0 {name=l326 sig_type=std_logic lab=b2}
C {lab_pin.sym} 5030 3360 0 0 {name=l327 sig_type=std_logic lab=b1}
C {lab_pin.sym} 5030 3380 0 0 {name=l328 sig_type=std_logic lab=nb0}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5280 330 0 0 {name=x97}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5290 510 0 0 {name=x98}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5290 680 0 0 {name=x99}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5280 820 0 0 {name=x100}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5290 980 0 0 {name=x101}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5300 1160 0 0 {name=x102}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 1340 0 0 {name=x103}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 1520 0 0 {name=x104}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 1730 0 0 {name=x105}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5280 1910 0 0 {name=x106}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5280 2080 0 0 {name=x107}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5280 2220 0 0 {name=x108}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5280 2380 0 0 {name=x109}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5290 2560 0 0 {name=x110}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 2740 0 0 {name=x111}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5280 2920 0 0 {name=x112}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5260 3160 0 0 {name=x113}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 3340 0 0 {name=x114}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 3510 0 0 {name=x115}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 3650 0 0 {name=x116}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 3810 0 0 {name=x117}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5280 3990 0 0 {name=x118}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 4170 0 0 {name=x119}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 4350 0 0 {name=x120}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 4510 0 0 {name=x121}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 4670 0 0 {name=x122}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 4810 0 0 {name=x123}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 4950 0 0 {name=x124}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 5110 0 0 {name=x125}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5270 5260 0 0 {name=x126}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5280 5420 0 0 {name=x127}
C {/home/shalini1234/Project/Switch_and_5Bit_AND.sym} 5290 5580 0 0 {name=x128}
C {lab_pin.sym} 5800 3030 0 0 {name=l359 sig_type=std_logic lab=Out}
C {lab_pin.sym} 5480 5630 0 0 {name=l360 sig_type=std_logic lab=GND}
C {lab_pin.sym} 5460 260 0 0 {name=l361 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 610 230 0 0 {name=l362 sig_type=std_logic lab=b8}
C {lab_pin.sym} 780 240 2 0 {name=l363 sig_type=std_logic lab=nb8}
C {lab_pin.sym} 860 220 0 0 {name=l364 sig_type=std_logic lab=b7}
C {lab_pin.sym} 1040 240 2 0 {name=l365 sig_type=std_logic lab=nb7}
C {lab_pin.sym} 1120 210 0 0 {name=l366 sig_type=std_logic lab=b6}
C {lab_pin.sym} 1300 240 2 0 {name=l367 sig_type=std_logic lab=nb6}
C {lab_pin.sym} 1380 210 0 0 {name=l368 sig_type=std_logic lab=b5}
C {lab_pin.sym} 1550 240 2 0 {name=l369 sig_type=std_logic lab=nb5}
C {lab_pin.sym} 300 490 0 0 {name=l370 sig_type=std_logic lab=b4}
C {lab_pin.sym} 490 520 2 0 {name=l371 sig_type=std_logic lab=nb4}
C {lab_pin.sym} 600 500 0 0 {name=l372 sig_type=std_logic lab=b3}
C {lab_pin.sym} 780 520 2 0 {name=l373 sig_type=std_logic lab=nb3}
C {lab_pin.sym} 860 490 0 0 {name=l374 sig_type=std_logic lab=b2}
C {lab_pin.sym} 1040 520 2 0 {name=l375 sig_type=std_logic lab=nb2}
C {lab_pin.sym} 1130 480 0 0 {name=l376 sig_type=std_logic lab=b1}
C {lab_pin.sym} 1310 520 2 0 {name=l377 sig_type=std_logic lab=nb1}
C {lab_pin.sym} 1390 500 0 0 {name=l378 sig_type=std_logic lab=b0}
C {lab_pin.sym} 1560 520 2 0 {name=l379 sig_type=std_logic lab=nb0}
